$ Spice netlist generated by v2lvs
$ v2019.1_18.11    Thu Jan 10 13:52:35 PST 2019
.INCLUDE "./stdcells.spi"
*.BUSDELIMITER [

.SUBCKT digital_top rst rst_prbs inj_error ref_clk_ext_p ref_clk_ext_n
+ CTL_BUF_N[5] CTL_BUF_N[4] CTL_BUF_N[3] CTL_BUF_N[2] CTL_BUF_N[1] CTL_BUF_N[0]
+ CTL_BUF_P[5] CTL_BUF_P[4] CTL_BUF_P[3] CTL_BUF_P[2] CTL_BUF_P[1] CTL_BUF_P[0]
+ osc_en aux_osc_en inj_en fftl_en con_perb[3] con_perb[2] con_perb[1]
+ con_perb[0] div_ratio_half[5] div_ratio_half[4] div_ratio_half[3]
+ div_ratio_half[2] div_ratio_half[1] div_ratio_half[0]
+ fine_control_avg_window_select[4] fine_control_avg_window_select[3]
+ fine_control_avg_window_select[2] fine_control_avg_window_select[1]
+ fine_control_avg_window_select[0] fine_con_step_size[3] fine_con_step_size[2]
+ fine_con_step_size[1] fine_con_step_size[0] manual_control_osc[12]
+ manual_control_osc[11] manual_control_osc[10] manual_control_osc[9]
+ manual_control_osc[8] manual_control_osc[7] manual_control_osc[6]
+ manual_control_osc[5] manual_control_osc[4] manual_control_osc[3]
+ manual_control_osc[2] manual_control_osc[1] manual_control_osc[0] pi1_con[3]
+ pi1_con[2] pi1_con[1] pi1_con[0] pi2_con[3] pi2_con[2] pi2_con[1] pi2_con[0]
+ pi3_con[3] pi3_con[2] pi3_con[1] pi3_con[0] pi4_con[3] pi4_con[2] pi4_con[1]
+ pi4_con[0] pi5_con[3] pi5_con[2] pi5_con[1] pi5_con[0] test_mux_select[3]
+ test_mux_select[2] test_mux_select[1] test_mux_select[0]
+ test_mux_clk_I_select[1] test_mux_clk_I_select[0] test_mux_clk_Q_select[1]
+ test_mux_clk_Q_select[0] dout_p dout_n test_mux_misc test_mux_clk_Q
+ test_mux_clk_I DVSS DVDD AVDD
XDIODE_1 din_reorder[1] DVSS DVSS DVDD DVDD sky130_fd_sc_hs__diode_2
XFE_OFC376_N485 N485 DVSS DVSS DVDD DVDD FE_OFN376_N485
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC43_N284 N284 DVSS DVSS DVDD DVDD FE_OFN43_N284 sky130_fd_sc_hs__buf_2
XFE_OFC42_N452 N452 DVSS DVSS DVDD DVDD FE_OFN42_N452 sky130_fd_sc_hs__buf_2
XFE_OFC41_N279 N279 DVSS DVSS DVDD DVDD FE_OFN41_N279 sky130_fd_sc_hs__buf_2
XFE_OFC40_N449 N449 DVSS DVSS DVDD DVDD FE_OFN40_N449 sky130_fd_sc_hs__buf_2
XFE_OFC39_N273 N273 DVSS DVSS DVDD DVDD FE_OFN39_N273 sky130_fd_sc_hs__buf_2
XFE_OFC38_N259 N259 DVSS DVSS DVDD DVDD FE_OFN38_N259 sky130_fd_sc_hs__buf_2
XFE_OFC37_N271 N271 DVSS DVSS DVDD DVDD FE_OFN37_N271 sky130_fd_sc_hs__buf_2
XFE_OFC36_N446 N446 DVSS DVSS DVDD DVDD FE_OFN36_N446 sky130_fd_sc_hs__buf_2
XFE_OFC35_N263 N263 DVSS DVSS DVDD DVDD FE_OFN35_N263 sky130_fd_sc_hs__buf_2
XFE_OFC34_manual_control_osc_3 manual_control_osc[3] DVSS DVSS DVDD DVDD
+ FE_OFN34_manual_control_osc_3 sky130_fd_sc_hs__buf_2
XFE_OFC33_N457 N457 DVSS DVSS DVDD DVDD FE_OFN33_N457 sky130_fd_sc_hs__buf_2
XFE_OFC32_N281 N281 DVSS DVSS DVDD DVDD FE_OFN32_N281 sky130_fd_sc_hs__buf_2
XFE_OFC31_pi3_con_1 pi3_con[1] DVSS DVSS DVDD DVDD FE_OFN31_pi3_con_1
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC30_N459 N459 DVSS DVSS DVDD DVDD FE_OFN30_N459 sky130_fd_sc_hs__buf_2
XFE_OFC29_N286 N286 DVSS DVSS DVDD DVDD FE_OFN29_N286 sky130_fd_sc_hs__buf_2
XFE_OFC28_N255 N255 DVSS DVSS DVDD DVDD FE_OFN28_N255 sky130_fd_sc_hs__buf_2
XFE_OFC27_N253 N253 DVSS DVSS DVDD DVDD FE_OFN27_N253 sky130_fd_sc_hs__buf_2
XFE_OFC26_N463 N463 DVSS DVSS DVDD DVDD FE_OFN26_N463 sky130_fd_sc_hs__buf_2
XFE_OFC25_N453 N453 DVSS DVSS DVDD DVDD FE_OFN25_N453 sky130_fd_sc_hs__buf_2
XFE_OFC24_pi1_con_0 pi1_con[0] DVSS DVSS DVDD DVDD FE_OFN24_pi1_con_0
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC23_CTL_P_30 CTL_P[30] DVSS DVSS DVDD DVDD FE_OFN23_CTL_P_30
+ sky130_fd_sc_hs__buf_2
XFE_OFC22_N276 N276 DVSS DVSS DVDD DVDD FE_OFN22_N276 sky130_fd_sc_hs__buf_2
XFE_OFC21_N274 N274 DVSS DVSS DVDD DVDD FE_OFN21_N274 sky130_fd_sc_hs__buf_2
XFE_OFC20_N280 N280 DVSS DVSS DVDD DVDD FE_OFN20_N280 sky130_fd_sc_hs__buf_2
XFE_OFC19_N470 N470 DVSS DVSS DVDD DVDD FE_OFN19_N470 sky130_fd_sc_hs__buf_2
XFE_OFC18_N260 N260 DVSS DVSS DVDD DVDD FE_OFN18_N260 sky130_fd_sc_hs__buf_2
XFE_OFC17_N277 N277 DVSS DVSS DVDD DVDD FE_OFN17_N277 sky130_fd_sc_hs__buf_2
XFE_OFC16_N288 N288 DVSS DVSS DVDD DVDD FE_OFN16_N288 sky130_fd_sc_hs__buf_2
XFE_OFC15_ck_Q ck_Q DVSS DVSS DVDD DVDD FE_OFN15_ck_Q sky130_fd_sc_hs__clkbuf_4
XFE_OFC14_N485 FE_OFN376_N485 DVSS DVSS DVDD DVDD FE_OFN14_N485
+ sky130_fd_sc_hs__buf_2
XFE_RC_13_0 FE_OFN40_N449 DVSS DVSS DVDD DVDD FE_OFN257_N449
+ sky130_fd_sc_hs__clkbuf_4
XFE_RC_12_0 N455 DVSS DVSS DVDD DVDD FE_OFN351_N455 sky130_fd_sc_hs__buf_2
XFE_RC_11_0 FE_OFN33_N457 DVSS DVSS DVDD DVDD FE_OFN248_N457
+ sky130_fd_sc_hs__buf_2
XFE_RC_10_1 FE_OFN25_N453 DVSS DVSS DVDD DVDD n2650 sky130_fd_sc_hs__inv_4
XFE_RC_8_1 FE_OFN37_N271 DVSS DVSS DVDD DVDD FE_OFN286_N271
+ sky130_fd_sc_hs__buf_2
XFE_RC_7_1 N469 DVSS DVSS DVDD DVDD n135 sky130_fd_sc_hs__inv_4
XFE_RC_6_1 FE_OFN41_N279 DVSS DVSS DVDD DVDD FE_OFN228_N279
+ sky130_fd_sc_hs__buf_2
XFE_RC_5_1 N285 DVSS DVSS DVDD DVDD FE_OFN206_N285 sky130_fd_sc_hs__buf_2
XFE_RC_4_0 FE_OFN29_N286 DVSS DVSS DVDD DVDD FE_OFN362_N286
+ sky130_fd_sc_hs__buf_2
XFE_RC_3_0 FE_OFN14_N485 DVSS DVSS DVDD DVDD FE_OFN201_N485
+ sky130_fd_sc_hs__clkbuf_4
XFE_RC_0_0 FE_OFN269_FE_MDBN0 DVSS DVSS DVDD DVDD test_mux_clk_Q
+ sky130_fd_sc_hs__inv_4
XFE_OFC9_CTL_N_10 CTL_N[10] DVSS DVSS DVDD DVDD FE_OFN9_CTL_N_10
+ sky130_fd_sc_hs__buf_2
XFE_OFC8_N263 FE_OFN35_N263 DVSS DVSS DVDD DVDD FE_OFN8_N263
+ sky130_fd_sc_hs__buf_2
XFE_OFC7_manual_control_osc_1 manual_control_osc[1] DVSS DVSS DVDD DVDD
+ FE_OFN7_manual_control_osc_1 sky130_fd_sc_hs__buf_2
XFE_OFC5_N466 N466 DVSS DVSS DVDD DVDD FE_OFN5_N466 sky130_fd_sc_hs__buf_2
XFE_OFC0_N261 N261 DVSS DVSS DVDD DVDD FE_OFN0_N261 sky130_fd_sc_hs__buf_2
XFE_OFC374_ck_I FE_OFN371_ck_I DVSS DVSS DVDD DVDD FE_OFN374_ck_I
+ sky130_fd_sc_hs__buf_4
XFE_OFC373_ck_I FE_OFN372_ck_I DVSS DVSS DVDD DVDD FE_OFN373_ck_I
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC372_ck_I ck_I DVSS DVSS DVDD DVDD FE_OFN372_ck_I sky130_fd_sc_hs__buf_1
XFE_OFC371_ck_I ck_I DVSS DVSS DVDD DVDD FE_OFN371_ck_I
+ sky130_fd_sc_hs__clkbuf_2
XCTS_ccl_a_buf_00003 ref_clk_ext_p DVSS DVSS DVDD DVDD CTS_1
+ sky130_fd_sc_hs__clkbuf_16
XLTIE_136 DVSS DVSS DVDD DVDD 1000 LTIE_136_LONET sky130_fd_sc_hs__conb_1
XLTIE_135 DVSS DVSS DVDD DVDD LTIE_135_HINET LTIE_135_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_134 DVSS DVSS DVDD DVDD 1001 LTIE_134_LONET sky130_fd_sc_hs__conb_1
XLTIE_133 DVSS DVSS DVDD DVDD LTIE_133_HINET LTIE_133_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_132 DVSS DVSS DVDD DVDD 1002 LTIE_132_LONET sky130_fd_sc_hs__conb_1
XLTIE_131 DVSS DVSS DVDD DVDD 1003 LTIE_131_LONET sky130_fd_sc_hs__conb_1
XLTIE_130 DVSS DVSS DVDD DVDD 1004 LTIE_130_LONET sky130_fd_sc_hs__conb_1
XLTIE_129 DVSS DVSS DVDD DVDD LTIE_129_HINET LTIE_129_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_128 DVSS DVSS DVDD DVDD LTIE_128_HINET LTIE_128_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_127 DVSS DVSS DVDD DVDD LTIE_127_HINET LTIE_127_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_126 DVSS DVSS DVDD DVDD LTIE_126_HINET LTIE_126_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_125 DVSS DVSS DVDD DVDD LTIE_125_HINET LTIE_125_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_124 DVSS DVSS DVDD DVDD LTIE_124_HINET LTIE_124_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_123 DVSS DVSS DVDD DVDD 1005 LTIE_123_LONET sky130_fd_sc_hs__conb_1
XLTIE_122 DVSS DVSS DVDD DVDD LTIE_122_HINET LTIE_122_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_121 DVSS DVSS DVDD DVDD LTIE_121_HINET LTIE_121_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_120 DVSS DVSS DVDD DVDD LTIE_120_HINET LTIE_120_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_119 DVSS DVSS DVDD DVDD LTIE_119_HINET LTIE_119_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_118 DVSS DVSS DVDD DVDD LTIE_118_HINET LTIE_118_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_117 DVSS DVSS DVDD DVDD LTIE_117_HINET LTIE_117_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_116 DVSS DVSS DVDD DVDD LTIE_116_HINET LTIE_116_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_115 DVSS DVSS DVDD DVDD LTIE_115_HINET LTIE_115_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_114 DVSS DVSS DVDD DVDD LTIE_114_HINET LTIE_114_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_113 DVSS DVSS DVDD DVDD LTIE_113_HINET LTIE_113_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_112 DVSS DVSS DVDD DVDD LTIE_112_HINET LTIE_112_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_111 DVSS DVSS DVDD DVDD LTIE_111_HINET LTIE_111_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_110 DVSS DVSS DVDD DVDD LTIE_110_HINET LTIE_110_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_109 DVSS DVSS DVDD DVDD 1006 LTIE_109_LONET sky130_fd_sc_hs__conb_1
XLTIE_108 DVSS DVSS DVDD DVDD 1007 LTIE_108_LONET sky130_fd_sc_hs__conb_1
XLTIE_107 DVSS DVSS DVDD DVDD LTIE_107_HINET LTIE_107_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_106 DVSS DVSS DVDD DVDD LTIE_106_HINET LTIE_106_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_105 DVSS DVSS DVDD DVDD LTIE_105_HINET LTIE_105_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_104 DVSS DVSS DVDD DVDD LTIE_104_HINET LTIE_104_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_103 DVSS DVSS DVDD DVDD LTIE_103_HINET LTIE_103_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_102 DVSS DVSS DVDD DVDD 1008 LTIE_102_LONET sky130_fd_sc_hs__conb_1
XLTIE_101 DVSS DVSS DVDD DVDD LTIE_101_HINET LTIE_101_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_100 DVSS DVSS DVDD DVDD LTIE_100_HINET LTIE_100_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_99 DVSS DVSS DVDD DVDD LTIE_99_HINET LTIE_99_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_98 DVSS DVSS DVDD DVDD 1009 LTIE_98_LONET sky130_fd_sc_hs__conb_1
XLTIE_97 DVSS DVSS DVDD DVDD LTIE_97_HINET LTIE_97_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_96 DVSS DVSS DVDD DVDD LTIE_96_HINET LTIE_96_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_95 DVSS DVSS DVDD DVDD 1010 LTIE_95_LONET sky130_fd_sc_hs__conb_1
XLTIE_94 DVSS DVSS DVDD DVDD LTIE_94_HINET LTIE_94_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_93 DVSS DVSS DVDD DVDD LTIE_93_HINET LTIE_93_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_92 DVSS DVSS DVDD DVDD LTIE_92_HINET LTIE_92_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_91 DVSS DVSS DVDD DVDD LTIE_91_HINET LTIE_91_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_90 DVSS DVSS DVDD DVDD 1011 LTIE_90_LONET sky130_fd_sc_hs__conb_1
XLTIE_89 DVSS DVSS DVDD DVDD 1012 LTIE_89_LONET sky130_fd_sc_hs__conb_1
XLTIE_88 DVSS DVSS DVDD DVDD 1013 LTIE_88_LONET sky130_fd_sc_hs__conb_1
XLTIE_87 DVSS DVSS DVDD DVDD LTIE_87_HINET LTIE_87_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_86 DVSS DVSS DVDD DVDD LTIE_86_HINET LTIE_86_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_85 DVSS DVSS DVDD DVDD 1014 LTIE_85_LONET sky130_fd_sc_hs__conb_1
XLTIE_84 DVSS DVSS DVDD DVDD LTIE_84_HINET LTIE_84_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_83 DVSS DVSS DVDD DVDD LTIE_83_HINET LTIE_83_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_82 DVSS DVSS DVDD DVDD LTIE_82_HINET LTIE_82_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_81 DVSS DVSS DVDD DVDD LTIE_81_HINET LTIE_81_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_80 DVSS DVSS DVDD DVDD 1015 LTIE_80_LONET sky130_fd_sc_hs__conb_1
XLTIE_79 DVSS DVSS DVDD DVDD LTIE_79_HINET 1016 sky130_fd_sc_hs__conb_1
XLTIE_78 DVSS DVSS DVDD DVDD LTIE_78_HINET 1017 sky130_fd_sc_hs__conb_1
XLTIE_77 DVSS DVSS DVDD DVDD LTIE_77_HINET LTIE_77_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_76 DVSS DVSS DVDD DVDD LTIE_76_HINET LTIE_76_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_75 DVSS DVSS DVDD DVDD LTIE_75_HINET 1018 sky130_fd_sc_hs__conb_1
XLTIE_74 DVSS DVSS DVDD DVDD LTIE_74_HINET 1019 sky130_fd_sc_hs__conb_1
XLTIE_73 DVSS DVSS DVDD DVDD 1020 LTIE_73_LONET sky130_fd_sc_hs__conb_1
XLTIE_72 DVSS DVSS DVDD DVDD LTIE_72_HINET 1021 sky130_fd_sc_hs__conb_1
XLTIE_71 DVSS DVSS DVDD DVDD LTIE_71_HINET LTIE_71_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_70 DVSS DVSS DVDD DVDD LTIE_70_HINET LTIE_70_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_69 DVSS DVSS DVDD DVDD LTIE_69_HINET LTIE_69_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_68 DVSS DVSS DVDD DVDD LTIE_68_HINET 1022 sky130_fd_sc_hs__conb_1
XLTIE_67 DVSS DVSS DVDD DVDD LTIE_67_HINET 1023 sky130_fd_sc_hs__conb_1
XLTIE_66 DVSS DVSS DVDD DVDD LTIE_66_HINET 1024 sky130_fd_sc_hs__conb_1
XLTIE_65 DVSS DVSS DVDD DVDD LTIE_65_HINET LTIE_65_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_64 DVSS DVSS DVDD DVDD 1025 LTIE_64_LONET sky130_fd_sc_hs__conb_1
XLTIE_63 DVSS DVSS DVDD DVDD LTIE_63_HINET LTIE_63_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_62 DVSS DVSS DVDD DVDD LTIE_62_HINET 1026 sky130_fd_sc_hs__conb_1
XLTIE_61 DVSS DVSS DVDD DVDD LTIE_61_HINET LTIE_61_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_60 DVSS DVSS DVDD DVDD LTIE_60_HINET 1027 sky130_fd_sc_hs__conb_1
XLTIE_59 DVSS DVSS DVDD DVDD LTIE_59_HINET 1028 sky130_fd_sc_hs__conb_1
XLTIE_58 DVSS DVSS DVDD DVDD LTIE_58_HINET 1029 sky130_fd_sc_hs__conb_1
XLTIE_57 DVSS DVSS DVDD DVDD 1030 LTIE_57_LONET sky130_fd_sc_hs__conb_1
XLTIE_56 DVSS DVSS DVDD DVDD LTIE_56_HINET LTIE_56_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_55 DVSS DVSS DVDD DVDD LTIE_55_HINET LTIE_55_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_54 DVSS DVSS DVDD DVDD LTIE_54_HINET LTIE_54_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_53 DVSS DVSS DVDD DVDD LTIE_53_HINET LTIE_53_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_52 DVSS DVSS DVDD DVDD 1031 LTIE_52_LONET sky130_fd_sc_hs__conb_1
XLTIE_51 DVSS DVSS DVDD DVDD LTIE_51_HINET LTIE_51_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_50 DVSS DVSS DVDD DVDD LTIE_50_HINET LTIE_50_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_49 DVSS DVSS DVDD DVDD 1032 LTIE_49_LONET sky130_fd_sc_hs__conb_1
XLTIE_48 DVSS DVSS DVDD DVDD 1033 LTIE_48_LONET sky130_fd_sc_hs__conb_1
XLTIE_47 DVSS DVSS DVDD DVDD LTIE_47_HINET LTIE_47_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_46 DVSS DVSS DVDD DVDD LTIE_46_HINET LTIE_46_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_45 DVSS DVSS DVDD DVDD LTIE_45_HINET LTIE_45_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_44 DVSS DVSS DVDD DVDD 1034 LTIE_44_LONET sky130_fd_sc_hs__conb_1
XLTIE_43 DVSS DVSS DVDD DVDD LTIE_43_HINET LTIE_43_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_42 DVSS DVSS DVDD DVDD 1035 LTIE_42_LONET sky130_fd_sc_hs__conb_1
XLTIE_41 DVSS DVSS DVDD DVDD LTIE_41_HINET LTIE_41_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_40 DVSS DVSS DVDD DVDD 1036 LTIE_40_LONET sky130_fd_sc_hs__conb_1
XLTIE_39 DVSS DVSS DVDD DVDD LTIE_39_HINET LTIE_39_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_38 DVSS DVSS DVDD DVDD 1037 LTIE_38_LONET sky130_fd_sc_hs__conb_1
XLTIE_37 DVSS DVSS DVDD DVDD LTIE_37_HINET LTIE_37_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_36 DVSS DVSS DVDD DVDD LTIE_36_HINET LTIE_36_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_35 DVSS DVSS DVDD DVDD LTIE_35_HINET LTIE_35_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_34 DVSS DVSS DVDD DVDD LTIE_34_HINET LTIE_34_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_33 DVSS DVSS DVDD DVDD LTIE_33_HINET LTIE_33_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_32 DVSS DVSS DVDD DVDD LTIE_32_HINET LTIE_32_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_31 DVSS DVSS DVDD DVDD 1038 LTIE_31_LONET sky130_fd_sc_hs__conb_1
XLTIE_30 DVSS DVSS DVDD DVDD LTIE_30_HINET LTIE_30_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_29 DVSS DVSS DVDD DVDD LTIE_29_HINET LTIE_29_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_28 DVSS DVSS DVDD DVDD LTIE_28_HINET LTIE_28_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_27 DVSS DVSS DVDD DVDD LTIE_27_HINET LTIE_27_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_26 DVSS DVSS DVDD DVDD 1039 LTIE_26_LONET sky130_fd_sc_hs__conb_1
XLTIE_25 DVSS DVSS DVDD DVDD LTIE_25_HINET LTIE_25_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_24 DVSS DVSS DVDD DVDD LTIE_24_HINET LTIE_24_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_23 DVSS DVSS DVDD DVDD 1040 LTIE_23_LONET sky130_fd_sc_hs__conb_1
XLTIE_22 DVSS DVSS DVDD DVDD 1041 LTIE_22_LONET sky130_fd_sc_hs__conb_1
XLTIE_21 DVSS DVSS DVDD DVDD LTIE_21_HINET LTIE_21_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_20 DVSS DVSS DVDD DVDD LTIE_20_HINET LTIE_20_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_19 DVSS DVSS DVDD DVDD LTIE_19_HINET LTIE_19_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_18 DVSS DVSS DVDD DVDD 1042 LTIE_18_LONET sky130_fd_sc_hs__conb_1
XLTIE_17 DVSS DVSS DVDD DVDD LTIE_17_HINET LTIE_17_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_16 DVSS DVSS DVDD DVDD 1043 LTIE_16_LONET sky130_fd_sc_hs__conb_1
XLTIE_15 DVSS DVSS DVDD DVDD LTIE_15_HINET LTIE_15_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_14 DVSS DVSS DVDD DVDD LTIE_14_HINET LTIE_14_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_13 DVSS DVSS DVDD DVDD LTIE_13_HINET LTIE_13_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_12 DVSS DVSS DVDD DVDD LTIE_12_HINET LTIE_12_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_11 DVSS DVSS DVDD DVDD LTIE_11_HINET LTIE_11_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_10 DVSS DVSS DVDD DVDD LTIE_10_HINET LTIE_10_LONET
+ sky130_fd_sc_hs__conb_1
XLTIE_9 DVSS DVSS DVDD DVDD 1044 LTIE_9_LONET sky130_fd_sc_hs__conb_1
XLTIE_8 DVSS DVSS DVDD DVDD LTIE_8_HINET LTIE_8_LONET sky130_fd_sc_hs__conb_1
XLTIE_7 DVSS DVSS DVDD DVDD LTIE_7_HINET LTIE_7_LONET sky130_fd_sc_hs__conb_1
XLTIE_6 DVSS DVSS DVDD DVDD LTIE_6_HINET LTIE_6_LONET sky130_fd_sc_hs__conb_1
XLTIE_5 DVSS DVSS DVDD DVDD LTIE_5_HINET LTIE_5_LONET sky130_fd_sc_hs__conb_1
XLTIE_4 DVSS DVSS DVDD DVDD LTIE_4_HINET LTIE_4_LONET sky130_fd_sc_hs__conb_1
XLTIE_3 DVSS DVSS DVDD DVDD LTIE_3_HINET LTIE_3_LONET sky130_fd_sc_hs__conb_1
XLTIE_2 DVSS DVSS DVDD DVDD LTIE_2_HINET LTIE_2_LONET sky130_fd_sc_hs__conb_1
XLTIE_1 DVSS DVSS DVDD DVDD LTIE_1_HINET LTIE_1_LONET sky130_fd_sc_hs__conb_1
XLTIE DVSS DVSS DVDD DVDD LTIE_HINET LTIE_LONET sky130_fd_sc_hs__conb_1
XFE_OFC370_N259 FE_OFN38_N259 DVSS DVSS DVDD DVDD FE_OFN370_N259
+ sky130_fd_sc_hs__buf_2
XFE_OFC363_N288 FE_OFN16_N288 DVSS DVSS DVDD DVDD FE_OFN363_N288
+ sky130_fd_sc_hs__buf_2
XFE_OFC361_N289 N289 DVSS DVSS DVDD DVDD FE_OFN361_N289 sky130_fd_sc_hs__buf_2
XFE_OFC358_N452 FE_OFN42_N452 DVSS DVSS DVDD DVDD FE_OFN358_N452
+ sky130_fd_sc_hs__buf_2
XFE_OFC357_n150 n150 DVSS DVSS DVDD DVDD FE_OFN357_n150 sky130_fd_sc_hs__buf_2
XFE_OFC356_N270 N270 DVSS DVSS DVDD DVDD FE_OFN356_N270 sky130_fd_sc_hs__buf_2
XFE_OFC355_N273 FE_OFN39_N273 DVSS DVSS DVDD DVDD FE_OFN355_N273
+ sky130_fd_sc_hs__buf_2
XFE_OFC354_N454 N454 DVSS DVSS DVDD DVDD FE_OFN354_N454 sky130_fd_sc_hs__buf_2
XFE_OFC353_n128 FE_OFN155_n128 DVSS DVSS DVDD DVDD FE_OFN353_n
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC352_N456 N456 DVSS DVSS DVDD DVDD FE_OFN352_N456 sky130_fd_sc_hs__buf_2
XFE_OFC349_N281 FE_OFN32_N281 DVSS DVSS DVDD DVDD FE_OFN349_N281
+ sky130_fd_sc_hs__buf_2
XFE_OFC348_N478 N478 DVSS DVSS DVDD DVDD FE_OFN348_N478 sky130_fd_sc_hs__buf_2
XFE_OFC347_FE_MDBN0 FE_MDBN0_ DVSS DVSS DVDD DVDD FE_OFN347_FE_MDBN0
+ sky130_fd_sc_hs__buf_2
XFE_OFC346_N274 N274 DVSS DVSS DVDD DVDD FE_OFN346_N274 sky130_fd_sc_hs__buf_2
XFE_OFC345_N468 N468 DVSS DVSS DVDD DVDD FE_OFN345_N468 sky130_fd_sc_hs__buf_2
XFE_OFC344_N460 N460 DVSS DVSS DVDD DVDD FE_OFN344_N460 sky130_fd_sc_hs__buf_2
XFE_OFC343_N275 N275 DVSS DVSS DVDD DVDD FE_OFN343_N275 sky130_fd_sc_hs__buf_2
XFE_OFC342_N465 N465 DVSS DVSS DVDD DVDD FE_OFN342_N465 sky130_fd_sc_hs__buf_2
XFE_OFC341_N470 FE_OFN19_N470 DVSS DVSS DVDD DVDD FE_OFN341_N470
+ sky130_fd_sc_hs__buf_2
XFE_OFC339_FE_OFN101_manual_control_osc_3 FE_OFN101_manual_control_osc_3 DVSS
+ DVSS DVDD DVDD FE_OFN339_FE_OFN101_manual_control_osc_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC338_N463 FE_OFN26_N463 DVSS DVSS DVDD DVDD FE_OFN338_N463
+ sky130_fd_sc_hs__buf_2
XFE_OFC336_CTL_N_4 CTL_N[4] DVSS DVSS DVDD DVDD FE_OFN336_CTL_N_4
+ sky130_fd_sc_hs__buf_2
XFE_OFC335_manual_control_osc_2 manual_control_osc[2] DVSS DVSS DVDD DVDD
+ FE_OFN335_manual_control_osc_2 sky130_fd_sc_hs__clkbuf_4
XFE_OFC334_CTL_P_17 CTL_P[17] DVSS DVSS DVDD DVDD FE_OFN334_CTL_P_17
+ sky130_fd_sc_hs__buf_2
XFE_OFC333_FE_OFN124_pi2_con_0 FE_OFN124_pi2_con_0 DVSS DVSS DVDD DVDD
+ FE_OFN333_FE_OFN124_pi2_con_0 sky130_fd_sc_hs__clkbuf_8
XFE_OFC332_manual_control_osc_10 manual_control_osc[10] DVSS DVSS DVDD DVDD
+ FE_OFN332_manual_control_osc_10 sky130_fd_sc_hs__clkbuf_4
XFE_OFC331_N479 N479 DVSS DVSS DVDD DVDD FE_OFN331_N479 sky130_fd_sc_hs__buf_2
XFE_OFC330_CTL_P_19 CTL_P[19] DVSS DVSS DVDD DVDD FE_OFN330_CTL_P_19
+ sky130_fd_sc_hs__buf_2
XFE_OFC329_manual_control_osc_11 manual_control_osc[11] DVSS DVSS DVDD DVDD
+ FE_OFN329_manual_control_osc_11 sky130_fd_sc_hs__buf_2
XFE_OFC326_FE_OFN13_inj_error FE_OFN13_inj_error DVSS DVSS DVDD DVDD
+ FE_OFN326_FE_OFN13_inj_error sky130_fd_sc_hs__clkbuf_4
XFE_OFC325_CTL_N_5 CTL_N[5] DVSS DVSS DVDD DVDD FE_OFN325_CTL_N_5
+ sky130_fd_sc_hs__buf_2
XFE_OFC324_N474 N474 DVSS DVSS DVDD DVDD FE_OFN324_N474 sky130_fd_sc_hs__buf_2
XFE_OFC323_CTL_N_14 CTL_N[14] DVSS DVSS DVDD DVDD FE_OFN323_CTL_N_14
+ sky130_fd_sc_hs__buf_2
XFE_OFC322_CTL_P_35 CTL_P[35] DVSS DVSS DVDD DVDD FE_OFN322_CTL_P_35
+ sky130_fd_sc_hs__buf_2
XFE_OFC321_CTL_BUF_P_1 CTL_BUF_P[1] DVSS DVSS DVDD DVDD FE_OFN321_CTL_BUF_P_1
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC320_CTL_P_39 CTL_P[39] DVSS DVSS DVDD DVDD FE_OFN320_CTL_P_39
+ sky130_fd_sc_hs__buf_2
XFE_OFC318_CTL_P_34 CTL_P[34] DVSS DVSS DVDD DVDD FE_OFN318_CTL_P_34
+ sky130_fd_sc_hs__buf_2
XFE_OFC317_CTL_N_35 CTL_N[35] DVSS DVSS DVDD DVDD FE_OFN317_CTL_N_35
+ sky130_fd_sc_hs__buf_2
XFE_OFC316_CTL_P_33 CTL_P[33] DVSS DVSS DVDD DVDD FE_OFN316_CTL_P_33
+ sky130_fd_sc_hs__buf_2
XFE_OFC315_CTL_BUF_P_3 CTL_BUF_P[3] DVSS DVSS DVDD DVDD FE_OFN315_CTL_BUF_P_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC311_N251 N251 DVSS DVSS DVDD DVDD FE_OFN311_N251 sky130_fd_sc_hs__buf_2
XFE_OFC310_pi3_con_2 pi3_con[2] DVSS DVSS DVDD DVDD FE_OFN310_pi3_con_2
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC308_N276 FE_OFN22_N276 DVSS DVSS DVDD DVDD FE_OFN308_N276
+ sky130_fd_sc_hs__buf_2
XFE_OFC307_N461 N461 DVSS DVSS DVDD DVDD FE_OFN307_N461
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC305_CTL_N_6 CTL_N[6] DVSS DVSS DVDD DVDD FE_OFN305_CTL_N_6
+ sky130_fd_sc_hs__buf_2
XFE_OFC304_CTL_N_0 CTL_N[0] DVSS DVSS DVDD DVDD FE_OFN304_CTL_N_0
+ sky130_fd_sc_hs__buf_2
XFE_OFC302_manual_control_osc_8 manual_control_osc[8] DVSS DVSS DVDD DVDD
+ FE_OFN302_manual_control_osc_8 sky130_fd_sc_hs__buf_2
XFE_OFC301_manual_control_osc_9 manual_control_osc[9] DVSS DVSS DVDD DVDD
+ FE_OFN301_manual_control_osc_9 sky130_fd_sc_hs__clkbuf_4
XFE_OFC300_pi5_con_1 pi5_con[1] DVSS DVSS DVDD DVDD FE_OFN300_pi5_con_1
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC299_CTL_BUF_N_1 CTL_BUF_N[1] DVSS DVSS DVDD DVDD FE_OFN299_CTL_BUF_N_1
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC298_CTL_BUF_N_3 CTL_BUF_N[3] DVSS DVSS DVDD DVDD FE_OFN298_CTL_BUF_N_3
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC297_CTL_BUF_P_0 CTL_BUF_P[0] DVSS DVSS DVDD DVDD FE_OFN297_CTL_BUF_P_0
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC296_pi5_con_3 pi5_con[3] DVSS DVSS DVDD DVDD FE_OFN296_pi5_con_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC295_fftl_en fftl_en DVSS DVSS DVDD DVDD FE_OFN295_fftl_en
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC294_CTL_BUF_N_4 CTL_BUF_N[4] DVSS DVSS DVDD DVDD FE_OFN294_CTL_BUF_N_4
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC293_CTL_BUF_N_0 CTL_BUF_N[0] DVSS DVSS DVDD DVDD FE_OFN293_CTL_BUF_N_0
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC292_N476 N476 DVSS DVSS DVDD DVDD FE_OFN292_N476 sky130_fd_sc_hs__buf_2
XFE_OFC291_rst rst DVSS DVSS DVDD DVDD FE_OFN291_rst sky130_fd_sc_hs__clkbuf_8
XFE_OFC290_N277 FE_OFN17_N277 DVSS DVSS DVDD DVDD FE_OFN290_N277
+ sky130_fd_sc_hs__buf_2
XFE_OFC287_N464 N464 DVSS DVSS DVDD DVDD FE_OFN287_N464 sky130_fd_sc_hs__buf_2
XFE_OFC286_N255 FE_OFN28_N255 DVSS DVSS DVDD DVDD FE_OFN286_N255
+ sky130_fd_sc_hs__buf_2
XFE_OFC285_pi5_con_2 pi5_con[2] DVSS DVSS DVDD DVDD FE_OFN285_pi5_con_2
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC284_manual_control_osc_12 manual_control_osc[12] DVSS DVSS DVDD DVDD
+ FE_OFN284_manual_control_osc_12 sky130_fd_sc_hs__clkbuf_4
XFE_OFC283_CTL_BUF_P_5 CTL_BUF_P[5] DVSS DVSS DVDD DVDD FE_OFN283_CTL_BUF_P_5
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC282_CTL_BUF_N_2 CTL_BUF_N[2] DVSS DVSS DVDD DVDD FE_OFN282_CTL_BUF_N_2
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC281_manual_control_osc_7 manual_control_osc[7] DVSS DVSS DVDD DVDD
+ FE_OFN281_manual_control_osc_7 sky130_fd_sc_hs__clkbuf_4
XFE_OFC280_CTL_BUF_N_5 CTL_BUF_N[5] DVSS DVSS DVDD DVDD FE_OFN280_CTL_BUF_N_5
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC279_pi3_con_3 pi3_con[3] DVSS DVSS DVDD DVDD FE_OFN279_pi3_con_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC275_pi1_con_1 pi1_con[1] DVSS DVSS DVDD DVDD FE_OFN275_pi1_con_1
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC274_manual_control_osc_4 manual_control_osc[4] DVSS DVSS DVDD DVDD
+ FE_OFN274_manual_control_osc_4 sky130_fd_sc_hs__clkbuf_4
XFE_OFC269_FE_MDBN0 FE_OFN347_FE_MDBN0 DVSS DVSS DVDD DVDD FE_OFN269_FE_MDBN0
+ sky130_fd_sc_hs__buf_2
XFE_RC_10_0 FE_OFN307_N461 DVSS DVSS DVDD DVDD n2640 sky130_fd_sc_hs__inv_4
XFE_RC_9_0 N283 DVSS DVSS DVDD DVDD FE_OFN214_N283 sky130_fd_sc_hs__clkbuf_2
XFE_RC_8_0 FE_OFN21_N274 DVSS DVSS DVDD DVDD n151 sky130_fd_sc_hs__inv_4
XFE_RC_7_0 FE_OFN347_FE_MDBN0 DVSS DVSS DVDD DVDD test_mux_clk_I
+ sky130_fd_sc_hs__clkinv_2
XFE_RC_6_0 n77 n76 DVSS DVSS DVDD DVDD FE_DBTN0_ibuf_inp_buf_0
+ sky130_fd_sc_hs__nand2_2
XFE_RC_5_0 test_buf_in_0 DVSS DVSS DVDD DVDD FE_OFN182_test_mux_misc
+ sky130_fd_sc_hs__inv_4
XFE_RC_1_0 ibuf_inn_buf_0 DVSS DVSS DVDD DVDD FE_OFN155_n128
+ sky130_fd_sc_hs__inv_4
XFE_OFC267_ck_QB ck_QB DVSS DVSS DVDD DVDD FE_OFN267_ck_QB
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC266_N446 FE_OFN36_N446 DVSS DVSS DVDD DVDD FE_OFN266_N446
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC265_N448 N448 DVSS DVSS DVDD DVDD FE_OFN265_N448
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC264_N447 N447 DVSS DVSS DVDD DVDD FE_OFN264_N447
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC258_N451 N451 DVSS DVSS DVDD DVDD FE_OFN258_N451
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC252_N252 N252 DVSS DVSS DVDD DVDD FE_OFN252_N252
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC250_N471 N471 DVSS DVSS DVDD DVDD FE_OFN250_N471
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC249_N459 FE_OFN30_N459 DVSS DVSS DVDD DVDD FE_OFN249_N459
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC244_N268 N268 DVSS DVSS DVDD DVDD FE_OFN244_N268
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC242_N260 FE_OFN18_N260 DVSS DVSS DVDD DVDD FE_OFN242_N260
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC240_N256 N256 DVSS DVSS DVDD DVDD FE_OFN240_N256
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC239_N254 N254 DVSS DVSS DVDD DVDD FE_OFN239_N254
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC238_n113 FE_OFN236_n113 DVSS DVSS DVDD DVDD FE_OFN238_n113
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC237_n113 FE_OFN236_n113 DVSS DVSS DVDD DVDD FE_OFN237_n113
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC236_n113 n113 DVSS DVSS DVDD DVDD FE_OFN236_n113
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC235_N482 N482 DVSS DVSS DVDD DVDD FE_OFN235_N482
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC231_N475 N475 DVSS DVSS DVDD DVDD FE_OFN231_N475
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC230_N473 N473 DVSS DVSS DVDD DVDD FE_OFN230_N473
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC224_N272 N272 DVSS DVSS DVDD DVDD FE_OFN224_N272
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC222_N265 N265 DVSS DVSS DVDD DVDD FE_OFN222_N265
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC221_N264 N264 DVSS DVSS DVDD DVDD FE_OFN221_N264
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC220_N262 N262 DVSS DVSS DVDD DVDD FE_OFN220_N262
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC219_n119 FE_OFN218_n119 DVSS DVSS DVDD DVDD FE_OFN219_n119
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC218_n119 n119 DVSS DVSS DVDD DVDD FE_OFN218_n119
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC217_N483 N483 DVSS DVSS DVDD DVDD FE_OFN217_N483
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC216_N481 N481 DVSS DVSS DVDD DVDD FE_OFN216_N481
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC215_N477 N477 DVSS DVSS DVDD DVDD FE_OFN215_N477
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC212_N280 FE_OFN20_N280 DVSS DVSS DVDD DVDD FE_OFN212_N280
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC211_N278 N278 DVSS DVSS DVDD DVDD FE_OFN211_N278
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC209_n2610 n2610 DVSS DVSS DVDD DVDD FE_OFN209_n2610
+ sky130_fd_sc_hs__buf_2
XFE_OFC208_N462 N462 DVSS DVSS DVDD DVDD FE_OFN208_N462
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC207_N287 N287 DVSS DVSS DVDD DVDD FE_OFN207_N287
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC205_N284 FE_OFN43_N284 DVSS DVSS DVDD DVDD FE_OFN205_N284
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC204_n130 FE_OFN202_n130 DVSS DVSS DVDD DVDD FE_OFN204_n130
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC203_n130 FE_OFN202_n130 DVSS DVSS DVDD DVDD FE_OFN203_n130
+ sky130_fd_sc_hs__buf_8
XFE_OFC202_n130 FE_DBTN0_ibuf_inp_buf_0 DVSS DVSS DVDD DVDD FE_OFN202_n130
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC195_N282 N282 DVSS DVSS DVDD DVDD FE_OFN195_N282
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC194_n2670 n2670 DVSS DVSS DVDD DVDD FE_OFN194_n2670
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC193_n163 n163 DVSS DVSS DVDD DVDD FE_OFN193_n163
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC192_n154 n154 DVSS DVSS DVDD DVDD FE_OFN192_n154
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC191_n147 n147 DVSS DVSS DVDD DVDD FE_OFN191_n147
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC190_n138 n138 DVSS DVSS DVDD DVDD FE_OFN190_n138
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC188_N467 N467 DVSS DVSS DVDD DVDD FE_OFN188_N467
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC187_N465 FE_OFN342_N465 DVSS DVSS DVDD DVDD FE_OFN187_N465
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC182_test_mux_misc FE_OFN182_test_mux_misc DVSS DVSS DVDD DVDD
+ test_mux_misc sky130_fd_sc_hs__clkbuf_16
XFE_OFC180_n162 n162 DVSS DVSS DVDD DVDD FE_OFN180_n162
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC179_n152 n152 DVSS DVSS DVDD DVDD FE_OFN179_n152
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC178_n150 FE_OFN357_n150 DVSS DVSS DVDD DVDD FE_OFN178_n150
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC177_n146 n146 DVSS DVSS DVDD DVDD FE_OFN177_n146
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC176_n136 FE_OFN175_n136 DVSS DVSS DVDD DVDD FE_OFN176_n136
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC175_n136 n136 DVSS DVSS DVDD DVDD FE_OFN175_n136
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC174_n134 n134 DVSS DVSS DVDD DVDD FE_OFN174_n134 sky130_fd_sc_hs__buf_8
XFE_OFC173_ck_IB ck_IB DVSS DVSS DVDD DVDD FE_OFN173_ck_IB
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC170_ck_Q ck_Q DVSS DVSS DVDD DVDD FE_OFN170_ck_Q
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC166_n160 n160 DVSS DVSS DVDD DVDD FE_OFN166_n160
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC165_n159 n159 DVSS DVSS DVDD DVDD FE_OFN165_n159
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC164_n159 n159 DVSS DVSS DVDD DVDD FE_OFN164_n159
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC163_n158 n158 DVSS DVSS DVDD DVDD FE_OFN163_n158
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC162_n144 n144 DVSS DVSS DVDD DVDD FE_OFN162_n144
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC161_n143 n143 DVSS DVSS DVDD DVDD FE_OFN161_n143
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC160_n142 n142 DVSS DVSS DVDD DVDD FE_OFN160_n142
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC159_CTL_P_18 CTL_P[18] DVSS DVSS DVDD DVDD FE_OFN159_CTL_P_18
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC158_CTL_N_7 CTL_N[7] DVSS DVSS DVDD DVDD FE_OFN158_CTL_N_7
+ sky130_fd_sc_hs__clkbuf_2
XFE_OFC157_n128 FE_OFN353_n DVSS DVSS DVDD DVDD FE_OFN157_n128
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC156_n128 FE_OFN155_n128 DVSS DVSS DVDD DVDD FE_OFN156_n128
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC154_clk_prbsgen FE_OFN153_clk_prbsgen DVSS DVSS DVDD DVDD
+ FE_OFN154_clk_prbsgen sky130_fd_sc_hs__clkbuf_16
XFE_OFC153_clk_prbsgen FE_OFN151_clk_prbsgen DVSS DVSS DVDD DVDD
+ FE_OFN153_clk_prbsgen sky130_fd_sc_hs__clkbuf_16
XFE_OFC152_clk_prbsgen FE_OFN151_clk_prbsgen DVSS DVSS DVDD DVDD
+ FE_OFN152_clk_prbsgen sky130_fd_sc_hs__clkbuf_16
XFE_OFC151_clk_prbsgen clk_prbsgen DVSS DVSS DVDD DVDD FE_OFN151_clk_prbsgen
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC150_test_mux_clk_Q_select_0 FE_OFN149_test_mux_clk_Q_select_0 DVSS DVSS
+ DVDD DVDD FE_OFN150_test_mux_clk_Q_select_0 sky130_fd_sc_hs__clkbuf_2
XFE_OFC149_test_mux_clk_Q_select_0 test_mux_clk_Q_select[0] DVSS DVSS DVDD DVDD
+ FE_OFN149_test_mux_clk_Q_select_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC148_test_mux_select_0 test_mux_select[0] DVSS DVSS DVDD DVDD
+ FE_OFN148_test_mux_select_0 sky130_fd_sc_hs__clkbuf_8
XFE_OFC147_test_mux_select_1 test_mux_select[1] DVSS DVSS DVDD DVDD
+ FE_OFN147_test_mux_select_1 sky130_fd_sc_hs__clkbuf_8
XFE_OFC146_test_mux_select_2 test_mux_select[2] DVSS DVSS DVDD DVDD
+ FE_OFN146_test_mux_select_2 sky130_fd_sc_hs__clkbuf_8
XFE_OFC144_test_mux_select_3 test_mux_select[3] DVSS DVSS DVDD DVDD
+ FE_OFN144_test_mux_select_3 sky130_fd_sc_hs__clkbuf_8
XFE_OFC143_pi5_con_0 pi5_con[0] DVSS DVSS DVDD DVDD FE_OFN143_pi5_con_0
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC142_pi5_con_1 FE_OFN300_pi5_con_1 DVSS DVSS DVDD DVDD
+ FE_OFN142_pi5_con_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC141_pi5_con_2 FE_OFN285_pi5_con_2 DVSS DVSS DVDD DVDD
+ FE_OFN141_pi5_con_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC139_pi5_con_3 FE_OFN296_pi5_con_3 DVSS DVSS DVDD DVDD
+ FE_OFN139_pi5_con_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC138_pi4_con_0 pi4_con[0] DVSS DVSS DVDD DVDD FE_OFN138_pi4_con_0
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC137_pi4_con_1 pi4_con[1] DVSS DVSS DVDD DVDD FE_OFN137_pi4_con_1
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC136_pi4_con_2 pi4_con[2] DVSS DVSS DVDD DVDD FE_OFN136_pi4_con_2
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC135_pi4_con_3 pi4_con[3] DVSS DVSS DVDD DVDD FE_OFN135_pi4_con_3
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC134_pi3_con_0 FE_OFN133_pi3_con_0 DVSS DVSS DVDD DVDD
+ FE_OFN134_pi3_con_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC133_pi3_con_0 pi3_con[0] DVSS DVSS DVDD DVDD FE_OFN133_pi3_con_0
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC132_pi3_con_1 FE_OFN131_pi3_con_1 DVSS DVSS DVDD DVDD
+ FE_OFN132_pi3_con_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC131_pi3_con_1 FE_OFN31_pi3_con_1 DVSS DVSS DVDD DVDD FE_OFN131_pi3_con_1
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC129_pi3_con_2 FE_OFN128_pi3_con_2 DVSS DVSS DVDD DVDD
+ FE_OFN129_pi3_con_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC128_pi3_con_2 FE_OFN310_pi3_con_2 DVSS DVSS DVDD DVDD
+ FE_OFN128_pi3_con_2 sky130_fd_sc_hs__clkbuf_8
XFE_OFC127_pi3_con_3 FE_OFN126_pi3_con_3 DVSS DVSS DVDD DVDD
+ FE_OFN127_pi3_con_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC126_pi3_con_3 FE_OFN279_pi3_con_3 DVSS DVSS DVDD DVDD
+ FE_OFN126_pi3_con_3 sky130_fd_sc_hs__clkbuf_8
XFE_OFC125_pi2_con_0 FE_OFN333_FE_OFN124_pi2_con_0 DVSS DVSS DVDD DVDD
+ FE_OFN125_pi2_con_0 sky130_fd_sc_hs__clkbuf_4
XFE_OFC124_pi2_con_0 FE_OFN123_pi2_con_0 DVSS DVSS DVDD DVDD
+ FE_OFN124_pi2_con_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC123_pi2_con_0 pi2_con[0] DVSS DVSS DVDD DVDD FE_OFN123_pi2_con_0
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC122_pi2_con_1 FE_OFN121_pi2_con_1 DVSS DVSS DVDD DVDD
+ FE_OFN122_pi2_con_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC121_pi2_con_1 pi2_con[1] DVSS DVSS DVDD DVDD FE_OFN121_pi2_con_1
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC120_pi2_con_2 FE_OFN119_pi2_con_2 DVSS DVSS DVDD DVDD
+ FE_OFN120_pi2_con_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC119_pi2_con_2 pi2_con[2] DVSS DVSS DVDD DVDD FE_OFN119_pi2_con_2
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC118_pi2_con_3 FE_OFN117_pi2_con_3 DVSS DVSS DVDD DVDD
+ FE_OFN118_pi2_con_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC117_pi2_con_3 pi2_con[3] DVSS DVSS DVDD DVDD FE_OFN117_pi2_con_3
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC116_pi1_con_0 FE_OFN115_pi1_con_0 DVSS DVSS DVDD DVDD
+ FE_OFN116_pi1_con_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC115_pi1_con_0 FE_OFN24_pi1_con_0 DVSS DVSS DVDD DVDD FE_OFN115_pi1_con_0
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC114_pi1_con_1 FE_OFN275_pi1_con_1 DVSS DVSS DVDD DVDD
+ FE_OFN114_pi1_con_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC112_pi1_con_2 FE_OFN111_pi1_con_2 DVSS DVSS DVDD DVDD
+ FE_OFN112_pi1_con_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC111_pi1_con_2 pi1_con[2] DVSS DVSS DVDD DVDD FE_OFN111_pi1_con_2
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC110_pi1_con_3 FE_OFN109_pi1_con_3 DVSS DVSS DVDD DVDD
+ FE_OFN110_pi1_con_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC109_pi1_con_3 pi1_con[3] DVSS DVSS DVDD DVDD FE_OFN109_pi1_con_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC108_manual_control_osc_0 FE_OFN107_manual_control_osc_0 DVSS DVSS DVDD
+ DVDD FE_OFN108_manual_control_osc_0 sky130_fd_sc_hs__clkbuf_4
XFE_OFC107_manual_control_osc_0 manual_control_osc[0] DVSS DVSS DVDD DVDD
+ FE_OFN107_manual_control_osc_0 sky130_fd_sc_hs__clkbuf_4
XFE_OFC106_manual_control_osc_1 FE_OFN105_manual_control_osc_1 DVSS DVSS DVDD
+ DVDD FE_OFN106_manual_control_osc_1 sky130_fd_sc_hs__clkbuf_8
XFE_OFC105_manual_control_osc_1 FE_OFN7_manual_control_osc_1 DVSS DVSS DVDD
+ DVDD FE_OFN105_manual_control_osc_1 sky130_fd_sc_hs__clkbuf_4
XFE_OFC104_manual_control_osc_2 FE_OFN103_manual_control_osc_2 DVSS DVSS DVDD
+ DVDD FE_OFN104_manual_control_osc_2 sky130_fd_sc_hs__clkbuf_8
XFE_OFC103_manual_control_osc_2 FE_OFN335_manual_control_osc_2 DVSS DVSS DVDD
+ DVDD FE_OFN103_manual_control_osc_2 sky130_fd_sc_hs__clkbuf_4
XFE_OFC102_manual_control_osc_3 FE_OFN339_FE_OFN101_manual_control_osc_3 DVSS
+ DVSS DVDD DVDD FE_OFN102_manual_control_osc_3 sky130_fd_sc_hs__clkbuf_8
XFE_OFC101_manual_control_osc_3 FE_OFN34_manual_control_osc_3 DVSS DVSS DVDD
+ DVDD FE_OFN101_manual_control_osc_3 sky130_fd_sc_hs__buf_2
XFE_OFC100_manual_control_osc_4 FE_OFN274_manual_control_osc_4 DVSS DVSS DVDD
+ DVDD FE_OFN100_manual_control_osc_4 sky130_fd_sc_hs__clkbuf_8
XFE_OFC98_manual_control_osc_5 FE_OFN97_manual_control_osc_5 DVSS DVSS DVDD
+ DVDD FE_OFN98_manual_control_osc_5 sky130_fd_sc_hs__clkbuf_8
XFE_OFC97_manual_control_osc_5 manual_control_osc[5] DVSS DVSS DVDD DVDD
+ FE_OFN97_manual_control_osc_5 sky130_fd_sc_hs__clkbuf_4
XFE_OFC96_manual_control_osc_6 FE_OFN95_manual_control_osc_6 DVSS DVSS DVDD
+ DVDD FE_OFN96_manual_control_osc_6 sky130_fd_sc_hs__clkbuf_16
XFE_OFC95_manual_control_osc_6 manual_control_osc[6] DVSS DVSS DVDD DVDD
+ FE_OFN95_manual_control_osc_6 sky130_fd_sc_hs__clkbuf_4
XFE_OFC92_manual_control_osc_7 FE_OFN281_manual_control_osc_7 DVSS DVSS DVDD
+ DVDD FE_OFN92_manual_control_osc_7 sky130_fd_sc_hs__clkbuf_16
XFE_OFC91_manual_control_osc_8 FE_OFN90_manual_control_osc_8 DVSS DVSS DVDD
+ DVDD FE_OFN91_manual_control_osc_8 sky130_fd_sc_hs__clkbuf_8
XFE_OFC90_manual_control_osc_8 FE_OFN302_manual_control_osc_8 DVSS DVSS DVDD
+ DVDD FE_OFN90_manual_control_osc_8 sky130_fd_sc_hs__clkbuf_4
XFE_OFC89_manual_control_osc_9 FE_OFN301_manual_control_osc_9 DVSS DVSS DVDD
+ DVDD FE_OFN89_manual_control_osc_9 sky130_fd_sc_hs__clkbuf_8
XFE_OFC85_manual_control_osc_10 FE_OFN332_manual_control_osc_10 DVSS DVSS DVDD
+ DVDD FE_OFN85_manual_control_osc_10 sky130_fd_sc_hs__clkbuf_8
XFE_OFC82_manual_control_osc_11 FE_OFN329_manual_control_osc_11 DVSS DVSS DVDD
+ DVDD FE_OFN82_manual_control_osc_11 sky130_fd_sc_hs__clkbuf_8
XFE_OFC79_manual_control_osc_12 FE_OFN284_manual_control_osc_12 DVSS DVSS DVDD
+ DVDD FE_OFN79_manual_control_osc_12 sky130_fd_sc_hs__clkbuf_8
XFE_OFC78_fine_con_step_size_0 fine_con_step_size[0] DVSS DVSS DVDD DVDD
+ FE_OFN78_fine_con_step_size_0 sky130_fd_sc_hs__clkbuf_4
XFE_OFC76_fine_con_step_size_1 fine_con_step_size[1] DVSS DVSS DVDD DVDD
+ FE_OFN76_fine_con_step_size_1 sky130_fd_sc_hs__clkbuf_4
XFE_OFC75_fine_con_step_size_2 fine_con_step_size[2] DVSS DVSS DVDD DVDD
+ FE_OFN75_fine_con_step_size_2 sky130_fd_sc_hs__clkbuf_4
XFE_OFC74_fine_con_step_size_3 fine_con_step_size[3] DVSS DVSS DVDD DVDD
+ FE_OFN74_fine_con_step_size_3 sky130_fd_sc_hs__clkbuf_4
XFE_OFC73_fine_control_avg_window_select_0 fine_control_avg_window_select[0]
+ DVSS DVSS DVDD DVDD FE_OFN73_fine_control_avg_window_select_0
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC72_fine_control_avg_window_select_1
+ FE_OFN71_fine_control_avg_window_select_1 DVSS DVSS DVDD DVDD
+ FE_OFN72_fine_control_avg_window_select_1 sky130_fd_sc_hs__clkinv_2
XFE_OFC71_fine_control_avg_window_select_1 fine_control_avg_window_select[1]
+ DVSS DVSS DVDD DVDD FE_OFN71_fine_control_avg_window_select_1
+ sky130_fd_sc_hs__inv_4
XFE_OFC69_fine_control_avg_window_select_2 fine_control_avg_window_select[2]
+ DVSS DVSS DVDD DVDD FE_OFN69_fine_control_avg_window_select_2
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC67_fine_control_avg_window_select_3 fine_control_avg_window_select[3]
+ DVSS DVSS DVDD DVDD FE_OFN67_fine_control_avg_window_select_3
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC65_fine_control_avg_window_select_4 fine_control_avg_window_select[4]
+ DVSS DVSS DVDD DVDD FE_OFN65_fine_control_avg_window_select_4
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC63_div_ratio_half_0 div_ratio_half[0] DVSS DVSS DVDD DVDD
+ FE_OFN63_div_ratio_half_0 sky130_fd_sc_hs__clkbuf_4
XFE_OFC62_div_ratio_half_1 div_ratio_half[1] DVSS DVSS DVDD DVDD
+ FE_OFN62_div_ratio_half_1 sky130_fd_sc_hs__clkbuf_4
XFE_OFC60_div_ratio_half_2 div_ratio_half[2] DVSS DVSS DVDD DVDD
+ FE_OFN60_div_ratio_half_2 sky130_fd_sc_hs__clkbuf_4
XFE_OFC59_div_ratio_half_3 div_ratio_half[3] DVSS DVSS DVDD DVDD
+ FE_OFN59_div_ratio_half_3 sky130_fd_sc_hs__clkbuf_4
XFE_OFC57_div_ratio_half_4 div_ratio_half[4] DVSS DVSS DVDD DVDD
+ FE_OFN57_div_ratio_half_4 sky130_fd_sc_hs__clkbuf_4
XFE_OFC56_div_ratio_half_5 div_ratio_half[5] DVSS DVSS DVDD DVDD
+ FE_OFN56_div_ratio_half_5 sky130_fd_sc_hs__clkbuf_4
XFE_OFC54_con_perb_0 con_perb[0] DVSS DVSS DVDD DVDD FE_OFN54_con_perb_0
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC52_con_perb_1 con_perb[1] DVSS DVSS DVDD DVDD FE_OFN52_con_perb_1
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC50_con_perb_2 con_perb[2] DVSS DVSS DVDD DVDD FE_OFN50_con_perb_2
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC48_con_perb_3 con_perb[3] DVSS DVSS DVDD DVDD FE_OFN48_con_perb_3
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC46_fftl_en FE_OFN295_fftl_en DVSS DVSS DVDD DVDD FE_OFN46_fftl_en
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC45_inj_en inj_en DVSS DVSS DVDD DVDD FE_OFN45_inj_en
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC42_aux_osc_en aux_osc_en DVSS DVSS DVDD DVDD FE_OFN42_aux_osc_en
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC41_osc_en osc_en DVSS DVSS DVDD DVDD FE_OFN41_osc_en
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC40_CTL_BUF_P_0 FE_OFN39_CTL_BUF_P_0 DVSS DVSS DVDD DVDD
+ FE_OFN40_CTL_BUF_P_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC39_CTL_BUF_P_0 FE_OFN297_CTL_BUF_P_0 DVSS DVSS DVDD DVDD
+ FE_OFN39_CTL_BUF_P_0 sky130_fd_sc_hs__clkbuf_8
XFE_OFC38_CTL_BUF_P_1 FE_OFN37_CTL_BUF_P_1 DVSS DVSS DVDD DVDD
+ FE_OFN38_CTL_BUF_P_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC37_CTL_BUF_P_1 FE_OFN321_CTL_BUF_P_1 DVSS DVSS DVDD DVDD
+ FE_OFN37_CTL_BUF_P_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC36_CTL_BUF_P_2 FE_OFN35_CTL_BUF_P_2 DVSS DVSS DVDD DVDD
+ FE_OFN36_CTL_BUF_P_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC35_CTL_BUF_P_2 CTL_BUF_P[2] DVSS DVSS DVDD DVDD FE_OFN35_CTL_BUF_P_2
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC34_CTL_BUF_P_3 FE_OFN33_CTL_BUF_P_3 DVSS DVSS DVDD DVDD
+ FE_OFN34_CTL_BUF_P_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC33_CTL_BUF_P_3 FE_OFN315_CTL_BUF_P_3 DVSS DVSS DVDD DVDD
+ FE_OFN33_CTL_BUF_P_3 sky130_fd_sc_hs__clkbuf_8
XFE_OFC32_CTL_BUF_P_4 FE_OFN31_CTL_BUF_P_4 DVSS DVSS DVDD DVDD
+ FE_OFN32_CTL_BUF_P_4 sky130_fd_sc_hs__clkbuf_16
XFE_OFC31_CTL_BUF_P_4 CTL_BUF_P[4] DVSS DVSS DVDD DVDD FE_OFN31_CTL_BUF_P_4
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC30_CTL_BUF_P_5 FE_OFN29_CTL_BUF_P_5 DVSS DVSS DVDD DVDD
+ FE_OFN30_CTL_BUF_P_5 sky130_fd_sc_hs__clkbuf_16
XFE_OFC29_CTL_BUF_P_5 FE_OFN283_CTL_BUF_P_5 DVSS DVSS DVDD DVDD
+ FE_OFN29_CTL_BUF_P_5 sky130_fd_sc_hs__clkbuf_16
XFE_OFC28_CTL_BUF_N_0 FE_OFN27_CTL_BUF_N_0 DVSS DVSS DVDD DVDD
+ FE_OFN28_CTL_BUF_N_0 sky130_fd_sc_hs__clkbuf_8
XFE_OFC27_CTL_BUF_N_0 FE_OFN293_CTL_BUF_N_0 DVSS DVSS DVDD DVDD
+ FE_OFN27_CTL_BUF_N_0 sky130_fd_sc_hs__clkbuf_16
XFE_OFC26_CTL_BUF_N_1 FE_OFN25_CTL_BUF_N_1 DVSS DVSS DVDD DVDD
+ FE_OFN26_CTL_BUF_N_1 sky130_fd_sc_hs__clkbuf_8
XFE_OFC25_CTL_BUF_N_1 FE_OFN299_CTL_BUF_N_1 DVSS DVSS DVDD DVDD
+ FE_OFN25_CTL_BUF_N_1 sky130_fd_sc_hs__clkbuf_16
XFE_OFC24_CTL_BUF_N_2 FE_OFN23_CTL_BUF_N_2 DVSS DVSS DVDD DVDD
+ FE_OFN24_CTL_BUF_N_2 sky130_fd_sc_hs__clkbuf_8
XFE_OFC23_CTL_BUF_N_2 FE_OFN282_CTL_BUF_N_2 DVSS DVSS DVDD DVDD
+ FE_OFN23_CTL_BUF_N_2 sky130_fd_sc_hs__clkbuf_16
XFE_OFC22_CTL_BUF_N_3 FE_OFN21_CTL_BUF_N_3 DVSS DVSS DVDD DVDD
+ FE_OFN22_CTL_BUF_N_3 sky130_fd_sc_hs__clkbuf_8
XFE_OFC21_CTL_BUF_N_3 FE_OFN298_CTL_BUF_N_3 DVSS DVSS DVDD DVDD
+ FE_OFN21_CTL_BUF_N_3 sky130_fd_sc_hs__clkbuf_16
XFE_OFC20_CTL_BUF_N_4 FE_OFN19_CTL_BUF_N_4 DVSS DVSS DVDD DVDD
+ FE_OFN20_CTL_BUF_N_4 sky130_fd_sc_hs__clkbuf_8
XFE_OFC19_CTL_BUF_N_4 FE_OFN294_CTL_BUF_N_4 DVSS DVSS DVDD DVDD
+ FE_OFN19_CTL_BUF_N_4 sky130_fd_sc_hs__clkbuf_8
XFE_OFC18_CTL_BUF_N_5 FE_OFN17_CTL_BUF_N_5 DVSS DVSS DVDD DVDD
+ FE_OFN18_CTL_BUF_N_5 sky130_fd_sc_hs__clkbuf_16
XFE_OFC17_CTL_BUF_N_5 FE_OFN280_CTL_BUF_N_5 DVSS DVSS DVDD DVDD
+ FE_OFN17_CTL_BUF_N_5 sky130_fd_sc_hs__clkbuf_16
XFE_OFC15_inj_error FE_OFN14_inj_error DVSS DVSS DVDD DVDD FE_OFN15_inj_error
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC14_inj_error FE_OFN326_FE_OFN13_inj_error DVSS DVSS DVDD DVDD
+ FE_OFN14_inj_error sky130_fd_sc_hs__clkbuf_4
XFE_OFC13_inj_error FE_OFN12_inj_error DVSS DVSS DVDD DVDD FE_OFN13_inj_error
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC12_inj_error FE_OFN11_inj_error DVSS DVSS DVDD DVDD FE_OFN12_inj_error
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC11_inj_error FE_OFN10_inj_error DVSS DVSS DVDD DVDD FE_OFN11_inj_error
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC10_inj_error inj_error DVSS DVSS DVDD DVDD FE_OFN10_inj_error
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC8_rst_prbs FE_OFN7_rst_prbs DVSS DVSS DVDD DVDD FE_OFN8_rst_prbs
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC7_rst_prbs FE_OFN6_rst_prbs DVSS DVSS DVDD DVDD FE_OFN7_rst_prbs
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC6_rst_prbs FE_OFN5_rst_prbs DVSS DVSS DVDD DVDD FE_OFN6_rst_prbs
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC5_rst_prbs FE_OFN4_rst_prbs DVSS DVSS DVDD DVDD FE_OFN5_rst_prbs
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC4_rst_prbs FE_OFN3_rst_prbs DVSS DVSS DVDD DVDD FE_OFN4_rst_prbs
+ sky130_fd_sc_hs__clkbuf_8
XFE_OFC3_rst_prbs rst_prbs DVSS DVSS DVDD DVDD FE_OFN3_rst_prbs
+ sky130_fd_sc_hs__clkbuf_4
XFE_OFC2_rst FE_OFN1_rst DVSS DVSS DVDD DVDD FE_OFN2_rst
+ sky130_fd_sc_hs__clkbuf_16
XFE_OFC1_rst FE_OFN0_rst DVSS DVSS DVDD DVDD FE_OFN1_rst
+ sky130_fd_sc_hs__clkinv_8
XFE_OFC0_rst FE_OFN291_rst DVSS DVSS DVDD DVDD FE_OFN0_rst
+ sky130_fd_sc_hs__clkinv_8
XFE_MDBC0_test_clk_Q_buf0 test_clk_buf_in_0 DVSS DVSS DVDD DVDD FE_MDBN0_
+ sky130_fd_sc_hs__clkbuf_16
Xgenblk1_0__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_92_HINET
+ LTIE_91_LONET LTIE_91_LONET LTIE_91_LONET LTIE_91_LONET LTIE_91_HINET
+ LTIE_91_HINET LTIE_91_HINET LTIE_91_HINET LTIE_91_HINET LTIE_91_HINET
+ LTIE_91_HINET LTIE_92_HINET LTIE_92_HINET LTIE_92_HINET LTIE_92_LONET
+ LTIE_92_HINET LTIE_92_LONET LTIE_92_HINET LTIE_104_LONET LTIE_104_LONET
+ LTIE_104_LONET LTIE_104_LONET LTIE_104_LONET LTIE_104_LONET LTIE_97_LONET
+ LTIE_97_HINET LTIE_97_HINET LTIE_97_LONET LTIE_97_LONET LTIE_97_HINET
+ LTIE_97_HINET LTIE_97_LONET LTIE_92_LONET LTIE_98_LONET LTIE_98_LONET
+ LTIE_102_LONET LTIE_102_LONET LTIE_102_LONET LTIE_102_LONET LTIE_102_LONET
+ LTIE_103_LONET LTIE_103_LONET LTIE_103_LONET LTIE_103_HINET LTIE_103_LONET
+ LTIE_103_LONET LTIE_103_LONET LTIE_103_LONET LTIE_107_LONET LTIE_107_LONET
+ LTIE_107_LONET LTIE_107_LONET LTIE_107_LONET LTIE_107_LONET LTIE_109_LONET
+ LTIE_109_LONET LTIE_109_LONET LTIE_109_LONET LTIE_109_LONET LTIE_109_LONET
+ LTIE_109_LONET LTIE_104_LONET LTIE_104_HINET LTIE_104_LONET
+ FE_OFN15_inj_error LTIE_92_LONET LTIE_92_LONET din_reorder[15] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_1__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_99_HINET
+ LTIE_93_LONET LTIE_93_LONET LTIE_93_HINET LTIE_93_HINET LTIE_93_HINET
+ LTIE_93_LONET LTIE_93_LONET LTIE_93_LONET LTIE_93_LONET LTIE_93_LONET
+ LTIE_93_LONET LTIE_94_LONET LTIE_94_LONET LTIE_94_HINET LTIE_94_LONET
+ LTIE_94_LONET LTIE_94_LONET LTIE_94_LONET LTIE_107_HINET LTIE_107_LONET
+ LTIE_103_HINET LTIE_103_LONET LTIE_103_HINET LTIE_103_HINET LTIE_102_LONET
+ LTIE_102_LONET LTIE_102_LONET LTIE_98_LONET LTIE_98_LONET LTIE_98_LONET
+ LTIE_98_LONET LTIE_98_LONET LTIE_99_LONET LTIE_99_LONET LTIE_99_LONET
+ LTIE_101_LONET LTIE_101_LONET LTIE_101_LONET LTIE_101_LONET LTIE_101_LONET
+ LTIE_101_LONET LTIE_101_LONET LTIE_106_LONET LTIE_106_HINET LTIE_106_LONET
+ LTIE_106_LONET LTIE_106_LONET LTIE_106_LONET LTIE_106_LONET LTIE_106_LONET
+ LTIE_106_LONET LTIE_111_LONET LTIE_111_LONET LTIE_111_LONET LTIE_111_LONET
+ LTIE_110_LONET LTIE_110_LONET LTIE_110_LONET LTIE_110_LONET LTIE_110_LONET
+ LTIE_110_LONET LTIE_110_LONET LTIE_110_HINET LTIE_107_LONET
+ FE_OFN15_inj_error LTIE_94_LONET LTIE_94_LONET din_reorder[11] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_2__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_100_HINET
+ LTIE_95_LONET LTIE_95_LONET LTIE_95_LONET LTIE_95_LONET LTIE_95_LONET
+ LTIE_95_LONET LTIE_95_LONET LTIE_95_LONET LTIE_96_LONET LTIE_96_LONET
+ LTIE_96_LONET LTIE_96_HINET LTIE_96_HINET LTIE_96_HINET LTIE_96_HINET
+ LTIE_96_HINET LTIE_96_HINET LTIE_96_HINET LTIE_106_HINET LTIE_106_HINET
+ LTIE_106_HINET LTIE_106_HINET LTIE_106_HINET LTIE_101_HINET LTIE_101_HINET
+ LTIE_101_HINET LTIE_101_HINET LTIE_99_HINET LTIE_99_HINET LTIE_99_HINET
+ LTIE_99_HINET LTIE_99_HINET LTIE_100_LONET LTIE_100_LONET LTIE_100_LONET
+ LTIE_100_LONET LTIE_100_LONET LTIE_100_LONET LTIE_100_LONET LTIE_100_LONET
+ LTIE_105_LONET LTIE_105_LONET LTIE_105_LONET LTIE_105_HINET LTIE_105_LONET
+ LTIE_105_LONET LTIE_105_LONET LTIE_105_LONET LTIE_105_LONET LTIE_108_LONET
+ LTIE_113_LONET LTIE_108_LONET LTIE_108_LONET LTIE_108_LONET LTIE_108_LONET
+ LTIE_108_LONET LTIE_108_LONET LTIE_108_LONET LTIE_112_LONET LTIE_112_LONET
+ LTIE_112_LONET LTIE_112_LONET LTIE_112_HINET LTIE_111_LONET
+ FE_OFN15_inj_error LTIE_96_LONET LTIE_96_LONET din_reorder[7] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_3__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_115_HINET
+ LTIE_114_LONET LTIE_114_LONET LTIE_114_HINET LTIE_114_HINET LTIE_114_HINET
+ LTIE_109_LONET LTIE_114_LONET LTIE_114_HINET LTIE_114_HINET LTIE_114_HINET
+ LTIE_114_HINET LTIE_115_HINET LTIE_115_HINET LTIE_115_LONET LTIE_115_HINET
+ LTIE_115_HINET LTIE_115_HINET LTIE_115_HINET LTIE_126_HINET LTIE_126_HINET
+ LTIE_126_HINET LTIE_126_HINET LTIE_126_HINET LTIE_126_LONET LTIE_120_LONET
+ LTIE_120_HINET LTIE_120_LONET LTIE_120_HINET LTIE_120_HINET LTIE_120_LONET
+ LTIE_120_LONET LTIE_120_HINET LTIE_115_LONET LTIE_121_LONET LTIE_121_LONET
+ LTIE_124_LONET LTIE_124_LONET LTIE_124_LONET LTIE_124_LONET LTIE_124_LONET
+ LTIE_124_LONET LTIE_127_LONET LTIE_127_LONET LTIE_127_HINET LTIE_127_LONET
+ LTIE_127_LONET LTIE_127_LONET LTIE_130_LONET LTIE_130_LONET LTIE_130_LONET
+ LTIE_133_LONET LTIE_130_LONET LTIE_130_LONET LTIE_130_LONET LTIE_132_LONET
+ LTIE_132_LONET LTIE_132_LONET LTIE_132_LONET LTIE_132_LONET LTIE_132_LONET
+ LTIE_132_LONET LTIE_126_LONET LTIE_126_HINET LTIE_126_LONET
+ FE_OFN15_inj_error LTIE_115_LONET LTIE_115_LONET din_reorder[3] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_4__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_117_HINET
+ LTIE_116_LONET LTIE_116_LONET LTIE_116_LONET LTIE_110_HINET LTIE_110_HINET
+ LTIE_110_HINET LTIE_110_HINET LTIE_110_HINET LTIE_116_HINET LTIE_116_HINET
+ LTIE_116_HINET LTIE_117_HINET LTIE_117_HINET LTIE_117_HINET LTIE_111_LONET
+ LTIE_111_HINET LTIE_111_LONET LTIE_111_HINET LTIE_130_LONET LTIE_130_LONET
+ LTIE_127_LONET LTIE_127_LONET LTIE_127_LONET LTIE_124_LONET LTIE_124_HINET
+ LTIE_124_HINET LTIE_124_LONET LTIE_121_LONET LTIE_121_HINET LTIE_121_HINET
+ LTIE_121_LONET LTIE_121_LONET LTIE_117_LONET LTIE_122_LONET LTIE_122_LONET
+ LTIE_125_LONET LTIE_125_LONET LTIE_125_LONET LTIE_125_LONET LTIE_125_LONET
+ LTIE_125_LONET LTIE_128_LONET LTIE_128_LONET LTIE_128_HINET LTIE_128_LONET
+ LTIE_128_LONET LTIE_128_LONET LTIE_128_LONET LTIE_128_LONET LTIE_131_LONET
+ LTIE_131_LONET LTIE_131_LONET LTIE_131_LONET LTIE_131_LONET LTIE_131_LONET
+ LTIE_134_LONET LTIE_134_LONET LTIE_134_LONET LTIE_134_LONET LTIE_133_LONET
+ LTIE_133_LONET LTIE_133_LONET LTIE_133_HINET LTIE_133_LONET
+ FE_OFN15_inj_error LTIE_111_LONET LTIE_117_LONET din_reorder[13] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_5__prbs_b FE_OFN152_clk_prbsgen FE_OFN8_rst_prbs LTIE_119_HINET
+ LTIE_118_LONET LTIE_112_LONET LTIE_112_HINET LTIE_112_HINET LTIE_112_HINET
+ LTIE_112_HINET LTIE_118_HINET LTIE_118_LONET LTIE_118_LONET LTIE_118_LONET
+ LTIE_118_LONET LTIE_119_LONET LTIE_113_LONET LTIE_113_HINET LTIE_113_LONET
+ LTIE_113_HINET LTIE_113_LONET LTIE_113_HINET LTIE_131_LONET LTIE_128_HINET
+ LTIE_128_HINET LTIE_128_HINET LTIE_128_HINET LTIE_125_LONET LTIE_125_LONET
+ LTIE_125_HINET LTIE_125_HINET LTIE_122_LONET LTIE_122_HINET LTIE_122_LONET
+ LTIE_122_HINET LTIE_122_LONET LTIE_119_LONET LTIE_123_LONET LTIE_123_LONET
+ LTIE_123_LONET LTIE_123_LONET LTIE_123_LONET LTIE_123_LONET LTIE_123_LONET
+ LTIE_123_LONET LTIE_129_LONET LTIE_129_LONET LTIE_129_HINET LTIE_129_LONET
+ LTIE_129_LONET LTIE_129_LONET LTIE_129_LONET LTIE_129_LONET LTIE_129_LONET
+ LTIE_136_LONET LTIE_136_LONET LTIE_136_LONET LTIE_136_LONET LTIE_136_LONET
+ LTIE_135_LONET LTIE_135_LONET LTIE_135_LONET LTIE_135_LONET LTIE_135_LONET
+ LTIE_135_LONET LTIE_135_LONET LTIE_135_HINET LTIE_131_LONET
+ FE_OFN15_inj_error LTIE_119_LONET LTIE_119_LONET din_reorder[9] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_6__prbs_b FE_OFN153_clk_prbsgen FE_OFN7_rst_prbs LTIE_83_HINET
+ LTIE_82_LONET LTIE_82_LONET LTIE_82_LONET LTIE_82_LONET LTIE_82_LONET
+ LTIE_82_LONET LTIE_82_HINET LTIE_82_HINET LTIE_82_HINET LTIE_82_HINET
+ LTIE_82_HINET LTIE_83_HINET LTIE_81_HINET LTIE_81_HINET LTIE_81_HINET
+ LTIE_81_HINET LTIE_81_LONET LTIE_81_HINET LTIE_86_LONET LTIE_86_HINET
+ LTIE_86_LONET LTIE_86_HINET LTIE_86_LONET LTIE_86_HINET LTIE_84_LONET
+ LTIE_84_HINET LTIE_84_LONET LTIE_84_LONET LTIE_84_HINET LTIE_84_HINET
+ LTIE_84_LONET LTIE_84_LONET LTIE_83_LONET LTIE_85_LONET LTIE_85_LONET
+ LTIE_85_LONET LTIE_85_LONET LTIE_85_LONET LTIE_85_LONET LTIE_85_LONET
+ LTIE_85_LONET LTIE_87_LONET LTIE_87_LONET LTIE_87_HINET LTIE_87_LONET
+ LTIE_87_LONET LTIE_87_LONET LTIE_87_LONET LTIE_87_LONET LTIE_87_LONET
+ LTIE_89_LONET LTIE_89_LONET LTIE_89_LONET LTIE_88_LONET LTIE_88_LONET
+ LTIE_88_LONET LTIE_88_LONET LTIE_88_LONET LTIE_88_LONET LTIE_88_LONET
+ LTIE_88_LONET LTIE_86_LONET LTIE_86_HINET LTIE_86_LONET FE_OFN13_inj_error
+ LTIE_83_LONET LTIE_83_LONET din_reorder[5] DVSS DVDD prbs_generator_syn
Xgenblk1_7__prbs_b FE_OFN153_clk_prbsgen FE_OFN6_rst_prbs LTIE_70_HINET
+ LTIE_69_LONET LTIE_69_LONET LTIE_69_HINET LTIE_69_HINET LTIE_69_HINET
+ LTIE_69_HINET LTIE_69_HINET LTIE_69_LONET LTIE_69_LONET LTIE_69_LONET
+ LTIE_69_LONET LTIE_70_LONET LTIE_65_HINET LTIE_65_LONET LTIE_65_HINET
+ LTIE_65_LONET LTIE_65_HINET LTIE_65_LONET LTIE_76_HINET LTIE_76_LONET
+ LTIE_76_LONET LTIE_76_LONET LTIE_76_LONET LTIE_76_HINET LTIE_71_HINET
+ LTIE_71_LONET LTIE_71_LONET LTIE_71_HINET LTIE_71_LONET LTIE_71_HINET
+ LTIE_71_LONET LTIE_71_HINET LTIE_70_LONET LTIE_73_LONET LTIE_73_LONET
+ LTIE_73_LONET LTIE_73_LONET LTIE_73_LONET LTIE_73_LONET LTIE_73_LONET
+ LTIE_73_LONET LTIE_77_LONET LTIE_77_LONET LTIE_77_HINET LTIE_77_LONET
+ LTIE_77_LONET LTIE_77_LONET LTIE_77_LONET LTIE_77_LONET LTIE_77_LONET
+ LTIE_81_LONET LTIE_81_LONET LTIE_81_LONET LTIE_80_LONET LTIE_80_LONET
+ LTIE_80_LONET LTIE_80_LONET LTIE_80_LONET LTIE_80_LONET LTIE_80_LONET
+ LTIE_80_LONET LTIE_76_LONET LTIE_76_HINET LTIE_76_LONET FE_OFN13_inj_error
+ LTIE_70_LONET LTIE_70_LONET din_reorder[1] DVSS DVDD prbs_generator_syn
Xgenblk1_8__prbs_b FE_OFN153_clk_prbsgen FE_OFN6_rst_prbs LTIE_55_HINET
+ LTIE_54_LONET LTIE_54_LONET LTIE_54_LONET LTIE_54_HINET LTIE_54_HINET
+ LTIE_54_HINET LTIE_54_HINET LTIE_54_HINET LTIE_54_LONET LTIE_54_LONET
+ LTIE_54_LONET LTIE_55_LONET LTIE_53_LONET LTIE_53_LONET LTIE_53_HINET
+ LTIE_53_LONET LTIE_53_HINET LTIE_53_LONET LTIE_61_HINET LTIE_61_LONET
+ LTIE_61_HINET LTIE_61_LONET LTIE_61_HINET LTIE_61_LONET LTIE_56_LONET
+ LTIE_56_HINET LTIE_56_HINET LTIE_56_LONET LTIE_56_LONET LTIE_56_LONET
+ LTIE_56_LONET LTIE_56_LONET LTIE_55_LONET LTIE_57_LONET LTIE_57_LONET
+ LTIE_57_LONET LTIE_57_LONET LTIE_57_LONET LTIE_57_LONET LTIE_57_LONET
+ LTIE_57_LONET LTIE_63_LONET LTIE_63_LONET LTIE_63_HINET LTIE_63_LONET
+ LTIE_63_LONET LTIE_63_LONET LTIE_63_LONET LTIE_63_LONET LTIE_63_LONET
+ LTIE_65_LONET LTIE_65_LONET LTIE_65_LONET LTIE_64_LONET LTIE_64_LONET
+ LTIE_64_LONET LTIE_64_LONET LTIE_64_LONET LTIE_64_LONET LTIE_64_LONET
+ LTIE_64_LONET LTIE_61_LONET LTIE_61_HINET LTIE_61_LONET FE_OFN13_inj_error
+ LTIE_55_LONET LTIE_55_LONET din_reorder[14] DVSS DVDD prbs_generator_syn
Xgenblk1_9__prbs_b FE_OFN153_clk_prbsgen FE_OFN6_rst_prbs LTIE_46_HINET
+ LTIE_45_LONET LTIE_45_LONET LTIE_45_HINET LTIE_45_HINET LTIE_45_LONET
+ LTIE_45_LONET LTIE_45_LONET LTIE_45_HINET LTIE_45_HINET LTIE_45_HINET
+ LTIE_45_HINET LTIE_46_HINET LTIE_46_LONET LTIE_46_HINET LTIE_46_LONET
+ LTIE_46_LONET LTIE_46_LONET LTIE_46_LONET LTIE_50_LONET LTIE_50_LONET
+ LTIE_50_LONET LTIE_50_LONET LTIE_50_LONET LTIE_50_HINET LTIE_47_HINET
+ LTIE_47_HINET LTIE_47_HINET LTIE_47_HINET LTIE_47_LONET LTIE_47_LONET
+ LTIE_47_HINET LTIE_47_HINET LTIE_46_LONET LTIE_48_LONET LTIE_48_LONET
+ LTIE_48_LONET LTIE_48_LONET LTIE_48_LONET LTIE_48_LONET LTIE_48_LONET
+ LTIE_48_LONET LTIE_51_LONET LTIE_51_LONET LTIE_51_HINET LTIE_51_LONET
+ LTIE_51_LONET LTIE_51_LONET LTIE_51_LONET LTIE_51_LONET LTIE_51_LONET
+ LTIE_53_LONET LTIE_53_LONET LTIE_53_LONET LTIE_52_LONET LTIE_52_LONET
+ LTIE_52_LONET LTIE_52_LONET LTIE_52_LONET LTIE_52_LONET LTIE_52_LONET
+ LTIE_52_LONET LTIE_50_LONET LTIE_50_HINET LTIE_50_LONET FE_OFN13_inj_error
+ LTIE_46_LONET LTIE_46_LONET din_reorder[10] DVSS DVDD prbs_generator_syn
Xgenblk1_10__prbs_b FE_OFN154_clk_prbsgen FE_OFN5_rst_prbs LTIE_29_HINET
+ LTIE_22_LONET LTIE_22_LONET LTIE_22_LONET LTIE_22_LONET LTIE_18_LONET
+ LTIE_18_LONET LTIE_22_LONET LTIE_22_LONET LTIE_22_LONET LTIE_22_LONET
+ LTIE_23_LONET LTIE_23_LONET LTIE_23_LONET LTIE_23_LONET LTIE_23_LONET
+ LTIE_23_LONET LTIE_23_LONET LTIE_23_LONET LTIE_34_LONET LTIE_34_LONET
+ LTIE_34_LONET LTIE_34_HINET LTIE_34_LONET LTIE_34_HINET LTIE_28_LONET
+ LTIE_28_HINET LTIE_28_LONET LTIE_28_HINET LTIE_28_LONET LTIE_28_HINET
+ LTIE_28_LONET LTIE_28_HINET LTIE_29_LONET LTIE_29_LONET LTIE_29_LONET
+ LTIE_33_LONET LTIE_33_LONET LTIE_33_LONET LTIE_33_LONET LTIE_33_LONET
+ LTIE_33_LONET LTIE_37_LONET LTIE_37_LONET LTIE_37_HINET LTIE_37_LONET
+ LTIE_37_LONET LTIE_37_LONET LTIE_37_LONET LTIE_39_LONET LTIE_39_LONET
+ LTIE_39_LONET LTIE_39_LONET LTIE_39_LONET LTIE_39_LONET LTIE_40_LONET
+ LTIE_40_LONET LTIE_40_LONET LTIE_40_LONET LTIE_40_LONET LTIE_40_LONET
+ LTIE_40_LONET LTIE_34_LONET LTIE_34_HINET LTIE_34_LONET FE_OFN12_inj_error
+ LTIE_29_LONET LTIE_29_LONET din_reorder[6] DVSS DVDD prbs_generator_syn
Xgenblk1_11__prbs_b FE_OFN154_clk_prbsgen FE_OFN5_rst_prbs LTIE_25_HINET
+ LTIE_24_LONET LTIE_24_LONET LTIE_24_HINET LTIE_19_HINET LTIE_19_LONET
+ LTIE_24_LONET LTIE_24_LONET LTIE_24_LONET LTIE_24_LONET LTIE_24_LONET
+ LTIE_24_LONET LTIE_25_LONET LTIE_25_HINET LTIE_25_LONET LTIE_17_HINET
+ LTIE_17_HINET LTIE_17_HINET LTIE_17_LONET LTIE_39_HINET LTIE_37_LONET
+ LTIE_37_HINET LTIE_37_LONET LTIE_37_HINET LTIE_33_HINET LTIE_33_LONET
+ LTIE_33_HINET LTIE_33_LONET LTIE_29_HINET LTIE_29_LONET LTIE_29_HINET
+ LTIE_29_LONET LTIE_29_HINET LTIE_25_LONET LTIE_30_LONET LTIE_30_LONET
+ LTIE_32_LONET LTIE_32_LONET LTIE_32_LONET LTIE_32_LONET LTIE_32_LONET
+ LTIE_32_LONET LTIE_35_LONET LTIE_35_LONET LTIE_35_HINET LTIE_35_LONET
+ LTIE_35_LONET LTIE_35_LONET LTIE_35_LONET LTIE_38_LONET LTIE_38_LONET
+ LTIE_38_LONET LTIE_38_LONET LTIE_38_LONET LTIE_38_LONET LTIE_42_LONET
+ LTIE_41_LONET LTIE_41_LONET LTIE_41_LONET LTIE_41_LONET LTIE_41_LONET
+ LTIE_41_LONET LTIE_41_LONET LTIE_41_HINET LTIE_39_LONET FE_OFN12_inj_error
+ LTIE_25_LONET LTIE_25_LONET din_reorder[2] DVSS DVDD prbs_generator_syn
Xgenblk1_12__prbs_b FE_OFN154_clk_prbsgen FE_OFN5_rst_prbs LTIE_27_HINET
+ LTIE_26_LONET LTIE_26_LONET LTIE_26_LONET LTIE_20_HINET LTIE_20_HINET
+ LTIE_20_HINET LTIE_20_HINET LTIE_20_HINET LTIE_26_LONET LTIE_26_LONET
+ LTIE_26_LONET LTIE_27_LONET LTIE_21_LONET LTIE_21_HINET LTIE_21_LONET
+ LTIE_21_HINET LTIE_21_LONET LTIE_27_HINET LTIE_38_LONET LTIE_35_HINET
+ LTIE_35_LONET LTIE_35_HINET LTIE_35_LONET LTIE_32_HINET LTIE_32_HINET
+ LTIE_32_LONET LTIE_32_LONET LTIE_30_HINET LTIE_30_HINET LTIE_30_HINET
+ LTIE_30_HINET LTIE_30_HINET LTIE_27_LONET LTIE_31_LONET LTIE_31_LONET
+ LTIE_31_LONET LTIE_31_LONET LTIE_31_LONET LTIE_31_LONET LTIE_31_LONET
+ LTIE_31_LONET LTIE_36_LONET LTIE_36_LONET LTIE_36_HINET LTIE_36_LONET
+ LTIE_36_LONET LTIE_36_LONET LTIE_36_LONET LTIE_36_LONET LTIE_36_LONET
+ LTIE_44_LONET LTIE_44_LONET LTIE_44_LONET LTIE_44_LONET LTIE_44_LONET
+ LTIE_43_LONET LTIE_43_LONET LTIE_43_LONET LTIE_43_LONET LTIE_43_LONET
+ LTIE_43_LONET LTIE_43_LONET LTIE_43_HINET LTIE_38_LONET FE_OFN12_inj_error
+ LTIE_27_LONET LTIE_27_LONET din_reorder[12] DVSS DVDD prbs_generator_syn
Xgenblk1_13__prbs_b FE_OFN154_clk_prbsgen FE_OFN5_rst_prbs LTIE_1_HINET
+ LTIE_LONET LTIE_LONET LTIE_HINET LTIE_HINET LTIE_HINET LTIE_HINET LTIE_HINET
+ LTIE_HINET LTIE_HINET LTIE_LONET LTIE_LONET LTIE_1_LONET LTIE_1_HINET
+ LTIE_1_LONET LTIE_1_HINET LTIE_1_LONET LTIE_1_HINET LTIE_1_HINET
+ LTIE_12_HINET LTIE_12_HINET LTIE_12_HINET LTIE_12_HINET LTIE_12_HINET
+ LTIE_12_LONET LTIE_6_LONET LTIE_6_HINET LTIE_6_HINET LTIE_6_LONET
+ LTIE_6_LONET LTIE_6_HINET LTIE_6_LONET LTIE_6_HINET LTIE_1_LONET LTIE_7_LONET
+ LTIE_7_LONET LTIE_11_LONET LTIE_11_LONET LTIE_11_LONET LTIE_11_LONET
+ LTIE_11_LONET LTIE_11_LONET LTIE_11_LONET LTIE_15_LONET LTIE_15_HINET
+ LTIE_15_LONET LTIE_15_LONET LTIE_15_LONET LTIE_15_LONET LTIE_15_LONET
+ LTIE_16_LONET LTIE_16_LONET LTIE_16_LONET LTIE_16_LONET LTIE_16_LONET
+ LTIE_16_LONET LTIE_18_LONET LTIE_18_LONET LTIE_18_LONET LTIE_18_LONET
+ LTIE_18_LONET LTIE_18_LONET LTIE_12_LONET LTIE_12_HINET LTIE_12_LONET
+ FE_OFN12_inj_error LTIE_1_LONET LTIE_1_LONET din_reorder[8] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_14__prbs_b FE_OFN154_clk_prbsgen FE_OFN4_rst_prbs LTIE_3_HINET
+ LTIE_2_LONET LTIE_2_LONET LTIE_2_LONET LTIE_2_LONET LTIE_2_LONET LTIE_2_HINET
+ LTIE_2_HINET LTIE_2_HINET LTIE_2_HINET LTIE_2_HINET LTIE_2_HINET LTIE_3_HINET
+ LTIE_3_HINET LTIE_3_HINET LTIE_3_HINET LTIE_3_HINET LTIE_3_LONET LTIE_3_HINET
+ LTIE_16_LONET LTIE_15_HINET LTIE_15_LONET LTIE_15_HINET LTIE_15_LONET
+ LTIE_11_HINET LTIE_11_LONET LTIE_11_HINET LTIE_11_HINET LTIE_7_LONET
+ LTIE_7_LONET LTIE_7_HINET LTIE_7_HINET LTIE_7_LONET LTIE_3_LONET LTIE_8_LONET
+ LTIE_8_LONET LTIE_10_LONET LTIE_10_LONET LTIE_10_LONET LTIE_10_LONET
+ LTIE_10_LONET LTIE_10_LONET LTIE_13_LONET LTIE_13_LONET LTIE_13_HINET
+ LTIE_13_LONET LTIE_13_LONET LTIE_13_LONET LTIE_13_LONET LTIE_13_LONET
+ LTIE_17_LONET LTIE_17_LONET LTIE_17_LONET LTIE_17_LONET LTIE_17_LONET
+ LTIE_17_LONET LTIE_19_LONET LTIE_19_LONET LTIE_19_LONET LTIE_19_LONET
+ LTIE_19_LONET LTIE_19_LONET LTIE_19_LONET LTIE_19_HINET LTIE_16_LONET
+ FE_OFN11_inj_error LTIE_3_LONET LTIE_3_LONET din_reorder[4] DVSS DVDD
+ prbs_generator_syn
Xgenblk1_15__prbs_b FE_OFN154_clk_prbsgen FE_OFN4_rst_prbs LTIE_5_HINET
+ LTIE_4_LONET LTIE_4_HINET LTIE_4_HINET LTIE_4_HINET LTIE_4_HINET LTIE_4_HINET
+ LTIE_4_HINET LTIE_4_HINET LTIE_4_HINET LTIE_4_LONET LTIE_4_LONET LTIE_5_LONET
+ LTIE_5_HINET LTIE_5_LONET LTIE_5_HINET LTIE_5_LONET LTIE_5_HINET LTIE_5_HINET
+ LTIE_17_HINET LTIE_13_HINET LTIE_13_HINET LTIE_13_HINET LTIE_13_LONET
+ LTIE_10_LONET LTIE_10_HINET LTIE_10_HINET LTIE_10_LONET LTIE_8_LONET
+ LTIE_8_HINET LTIE_8_HINET LTIE_8_HINET LTIE_8_HINET LTIE_5_LONET LTIE_9_LONET
+ LTIE_9_LONET LTIE_9_LONET LTIE_9_LONET LTIE_9_LONET LTIE_9_LONET LTIE_9_LONET
+ LTIE_9_LONET LTIE_14_LONET LTIE_14_LONET LTIE_14_HINET LTIE_14_LONET
+ LTIE_14_LONET LTIE_14_LONET LTIE_14_LONET LTIE_14_LONET LTIE_14_LONET
+ LTIE_21_LONET LTIE_21_LONET LTIE_21_LONET LTIE_21_LONET LTIE_21_LONET
+ LTIE_20_LONET LTIE_20_LONET LTIE_20_LONET LTIE_20_LONET LTIE_20_LONET
+ LTIE_20_LONET LTIE_20_LONET LTIE_20_HINET LTIE_17_LONET FE_OFN11_inj_error
+ LTIE_5_LONET LTIE_5_LONET din_reorder[0] DVSS DVDD prbs_generator_syn
Xhr_mux_16t4_0 FE_OFN373_ck_I din_reorder[15] din_reorder[14] din_reorder[13]
+ din_reorder[12] din_reorder[11] din_reorder[10] din_reorder[9] din_reorder[8]
+ din_reorder[7] din_reorder[6] din_reorder[5] din_reorder[4] din_reorder[3]
+ din_reorder[2] din_reorder[1] din_reorder[0] FE_OFN2_rst n96 qr_data_p[3]
+ qr_data_p[2] qr_data_p[1] qr_data_p[0] DVSS DVDD hr_16t4_mux_top
Xqr_mux_4t1_0 FE_OFN15_ck_Q FE_OFN373_ck_I FE_OFN267_ck_QB FE_OFN173_ck_IB
+ qr_data_p[3] qr_data_p[2] qr_data_p[1] qr_data_p[0] FE_OFN2_rst LTIE_90_LONET
+ LTIE_90_LONET LTIE_90_LONET LTIE_90_LONET dout_p 1045 DVSS DVDD
+ qr_4t1_mux_top
Xhr_mux_16t4_1 FE_OFN374_ck_I n_48_net__15_ n_48_net__14_ n_48_net__13_
+ n_48_net__12_ n_48_net__11_ n_48_net__10_ n_48_net__9_ n_48_net__8_
+ n_48_net__7_ n_48_net__6_ n_48_net__5_ n_48_net__4_ n_48_net__3_ n_48_net__2_
+ n_48_net__1_ n_48_net__0_ FE_OFN1_rst n97 qr_data_n[3] qr_data_n[2]
+ qr_data_n[1] qr_data_n[0] DVSS DVDD hr_16t4_mux_top
Xqr_mux_4t1_1 FE_OFN170_ck_Q FE_OFN374_ck_I FE_OFN267_ck_QB ck_IB qr_data_n[3]
+ qr_data_n[2] qr_data_n[1] qr_data_n[0] FE_OFN1_rst LTIE_49_LONET
+ LTIE_49_LONET LTIE_49_LONET LTIE_49_LONET dout_n 1046 DVSS DVDD
+ qr_4t1_mux_top
Xosc_inst FE_OFN41_osc_en osc_con[4] osc_con[3] osc_con[2] osc_con[1]
+ osc_con[0] osc_con[12] osc_con[11] osc_con[10] osc_con[9] osc_con[8]
+ osc_con[7] osc_con[6] osc_con[5] FE_OFN48_con_perb_3 FE_OFN50_con_perb_2
+ FE_OFN52_con_perb_1 FE_OFN54_con_perb_0 FE_OFN48_con_perb_3
+ FE_OFN50_con_perb_2 FE_OFN52_con_perb_1 FE_OFN54_con_perb_0
+ FE_OFN48_con_perb_3 FE_OFN50_con_perb_2 FE_OFN52_con_perb_1
+ FE_OFN54_con_perb_0 FE_OFN48_con_perb_3 FE_OFN50_con_perb_2
+ FE_OFN52_con_perb_1 FE_OFN54_con_perb_0 FE_OFN48_con_perb_3
+ FE_OFN50_con_perb_2 FE_OFN52_con_perb_1 FE_OFN54_con_perb_0 CTS_1
+ FE_OFN110_pi1_con_3 FE_OFN112_pi1_con_2 FE_OFN114_pi1_con_1
+ FE_OFN116_pi1_con_0 n211 n57 n58 n59 FE_OFN118_pi2_con_3 FE_OFN120_pi2_con_2
+ FE_OFN122_pi2_con_1 FE_OFN125_pi2_con_0 n210 n208 n206 n204
+ FE_OFN127_pi3_con_3 FE_OFN129_pi3_con_2 FE_OFN132_pi3_con_1
+ FE_OFN134_pi3_con_0 n202 n200 n198 n196 FE_OFN135_pi4_con_3
+ FE_OFN136_pi4_con_2 FE_OFN137_pi4_con_1 FE_OFN138_pi4_con_0 n195 n193 n191
+ n189 FE_OFN139_pi5_con_3 FE_OFN141_pi5_con_2 FE_OFN142_pi5_con_1
+ FE_OFN143_pi5_con_0 n187 n185 n183 n181 1047 1048 1049 1050 1051
+ FE_OFN45_inj_en test_inj_out test_inj_hold pi1 1052 pi3 1053 pi5 DVSS AVDD
+ osc_core
Xftl pi3 FE_OFN56_div_ratio_half_5 FE_OFN57_div_ratio_half_4
+ FE_OFN59_div_ratio_half_3 FE_OFN60_div_ratio_half_2 FE_OFN62_div_ratio_half_1
+ FE_OFN63_div_ratio_half_0 CTS_1 FE_OFN2_rst FE_OFN42_aux_osc_en
+ FE_OFN46_fftl_en FE_OFN65_fine_control_avg_window_select_4
+ FE_OFN67_fine_control_avg_window_select_3
+ FE_OFN69_fine_control_avg_window_select_2
+ FE_OFN72_fine_control_avg_window_select_1
+ FE_OFN73_fine_control_avg_window_select_0 FE_OFN74_fine_con_step_size_3
+ FE_OFN75_fine_con_step_size_2 FE_OFN76_fine_con_step_size_1
+ FE_OFN78_fine_con_step_size_0 FE_OFN79_manual_control_osc_12
+ FE_OFN82_manual_control_osc_11 FE_OFN85_manual_control_osc_10
+ FE_OFN89_manual_control_osc_9 FE_OFN91_manual_control_osc_8
+ FE_OFN92_manual_control_osc_7 FE_OFN96_manual_control_osc_6
+ FE_OFN98_manual_control_osc_5 FE_OFN100_manual_control_osc_4
+ FE_OFN102_manual_control_osc_3 FE_OFN104_manual_control_osc_2
+ FE_OFN106_manual_control_osc_1 FE_OFN108_manual_control_osc_0 test_aux_clk
+ test_out_star osc_con[12] osc_con[11] osc_con[10] osc_con[9] osc_con[8]
+ osc_con[7] osc_con[6] osc_con[5] osc_con[4] osc_con[3] osc_con[2] osc_con[1]
+ osc_con[0] DVSS DVDD fine_freq_track
Xtest_mux_0 test_out_star FE_OFN148_test_mux_select_0 DVSS DVSS DVDD DVDD
+ test_buf_in_0 sky130_fd_sc_hs__einvp_8
Xtest_mux_1 test_inj_out FE_OFN147_test_mux_select_1 DVSS DVSS DVDD DVDD
+ test_buf_in_0 sky130_fd_sc_hs__einvp_8
Xtest_mux_2 test_aux_clk FE_OFN146_test_mux_select_2 DVSS DVSS DVDD DVDD
+ test_buf_in_0 sky130_fd_sc_hs__einvp_8
Xtest_mux_3 test_inj_hold FE_OFN144_test_mux_select_3 DVSS DVSS DVDD DVDD
+ test_buf_in_0 sky130_fd_sc_hs__einvp_8
Xtest_mux_Q0 pi1 FE_OFN150_test_mux_clk_Q_select_0 DVSS DVSS DVDD DVDD
+ test_clk_buf_in_0 sky130_fd_sc_hs__einvp_8
Xtest_mux_Q1 pi5 FE_OFN149_test_mux_clk_Q_select_0 DVSS DVSS DVDD DVDD
+ test_clk_buf_in_0 sky130_fd_sc_hs__einvp_8
Xibuf_genblk1_39__i_tri_buf_p FE_OFN204_n130 FE_OFN330_CTL_P_19 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_39__i_tri_buf_n FE_OFN156_n128 CTL_N[19] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_38__i_tri_buf_p FE_OFN204_n130 FE_OFN159_CTL_P_18 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_38__i_tri_buf_n FE_OFN156_n128 CTL_N[18] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_37__i_tri_buf_p FE_OFN204_n130 FE_OFN334_CTL_P_17 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_37__i_tri_buf_n FE_OFN156_n128 CTL_N[17] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_36__i_tri_buf_p FE_OFN204_n130 CTL_P[16] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_36__i_tri_buf_n FE_OFN156_n128 CTL_N[16] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_35__i_tri_buf_p FE_OFN202_n130 CTL_P[15] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_35__i_tri_buf_n FE_OFN156_n128 CTL_N[15] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_34__i_tri_buf_p FE_OFN202_n130 CTL_P[14] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_34__i_tri_buf_n FE_OFN156_n128 FE_OFN323_CTL_N_14 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_33__i_tri_buf_p FE_OFN204_n130 CTL_P[13] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_33__i_tri_buf_n FE_OFN156_n128 CTL_N[13] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_32__i_tri_buf_p FE_OFN204_n130 CTL_P[12] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_32__i_tri_buf_n FE_OFN157_n128 CTL_N[12] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_31__i_tri_buf_p FE_OFN204_n130 CTL_P[11] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_31__i_tri_buf_n FE_OFN157_n128 CTL_N[11] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_30__i_tri_buf_p FE_OFN204_n130 CTL_P[10] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_30__i_tri_buf_n FE_OFN157_n128 FE_OFN9_CTL_N_10 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_29__i_tri_buf_p FE_OFN202_n130 CTL_P[9] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_29__i_tri_buf_n FE_OFN156_n128 CTL_N[9] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_28__i_tri_buf_p FE_OFN202_n130 CTL_P[8] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_28__i_tri_buf_n FE_OFN156_n128 CTL_N[8] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_27__i_tri_buf_p FE_OFN204_n130 CTL_P[7] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_27__i_tri_buf_n FE_OFN156_n128 FE_OFN158_CTL_N_7 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_26__i_tri_buf_p FE_OFN204_n130 CTL_P[6] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_26__i_tri_buf_n FE_OFN157_n128 FE_OFN305_CTL_N_6 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_25__i_tri_buf_p FE_OFN204_n130 CTL_P[5] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_25__i_tri_buf_n FE_OFN157_n128 FE_OFN325_CTL_N_5 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_24__i_tri_buf_p FE_OFN204_n130 CTL_P[4] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_24__i_tri_buf_n FE_OFN157_n128 FE_OFN336_CTL_N_4 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_23__i_tri_buf_p FE_OFN202_n130 CTL_P[3] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_23__i_tri_buf_n FE_OFN156_n128 CTL_N[3] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_22__i_tri_buf_p FE_OFN204_n130 CTL_P[2] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_22__i_tri_buf_n FE_OFN156_n128 CTL_N[2] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_21__i_tri_buf_p FE_OFN204_n130 CTL_P[1] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_21__i_tri_buf_n FE_OFN156_n128 CTL_N[1] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_20__i_tri_buf_p FE_OFN204_n130 CTL_P[0] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_20__i_tri_buf_n FE_OFN157_n128 FE_OFN304_CTL_N_0 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_19__i_tri_buf_p FE_OFN204_n130 FE_OFN320_CTL_P_39 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_19__i_tri_buf_n FE_OFN157_n128 CTL_N[39] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_18__i_tri_buf_p FE_OFN204_n130 CTL_P[38] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_18__i_tri_buf_n FE_OFN157_n128 CTL_N[38] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_17__i_tri_buf_p FE_OFN202_n130 CTL_P[37] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_17__i_tri_buf_n FE_OFN156_n128 CTL_N[37] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_16__i_tri_buf_p FE_OFN202_n130 CTL_P[36] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_16__i_tri_buf_n FE_OFN156_n128 CTL_N[36] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_15__i_tri_buf_p FE_OFN202_n130 FE_OFN322_CTL_P_35 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_15__i_tri_buf_n FE_OFN156_n128 FE_OFN317_CTL_N_35 DVSS DVSS DVDD
+ DVDD dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_14__i_tri_buf_p FE_OFN203_n130 FE_OFN318_CTL_P_34 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_14__i_tri_buf_n FE_OFN157_n128 CTL_N[34] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_13__i_tri_buf_p FE_OFN203_n130 FE_OFN316_CTL_P_33 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_13__i_tri_buf_n FE_OFN157_n128 CTL_N[33] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_12__i_tri_buf_p FE_OFN203_n130 CTL_P[32] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_12__i_tri_buf_n FE_OFN157_n128 CTL_N[32] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_11__i_tri_buf_p FE_OFN202_n130 CTL_P[31] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_11__i_tri_buf_n FE_OFN156_n128 CTL_N[31] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_10__i_tri_buf_p FE_OFN202_n130 FE_OFN23_CTL_P_30 DVSS DVSS DVDD
+ DVDD dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_10__i_tri_buf_n FE_OFN353_n CTL_N[30] DVSS DVSS DVDD DVDD dout_p
+ sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_9__i_tri_buf_p FE_OFN202_n130 CTL_P[29] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_9__i_tri_buf_n FE_OFN353_n CTL_N[29] DVSS DVSS DVDD DVDD dout_p
+ sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_8__i_tri_buf_p FE_OFN203_n130 CTL_P[28] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_8__i_tri_buf_n FE_OFN157_n128 CTL_N[28] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_7__i_tri_buf_p FE_OFN203_n130 CTL_P[27] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_7__i_tri_buf_n FE_OFN157_n128 CTL_N[27] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_6__i_tri_buf_p FE_OFN203_n130 CTL_P[26] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_6__i_tri_buf_n FE_OFN157_n128 CTL_N[26] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_5__i_tri_buf_p FE_OFN202_n130 CTL_P[25] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_5__i_tri_buf_n FE_OFN155_n128 CTL_N[25] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_4__i_tri_buf_p FE_OFN202_n130 CTL_P[24] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_4__i_tri_buf_n FE_OFN155_n128 CTL_N[24] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_3__i_tri_buf_p FE_OFN202_n130 CTL_P[23] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_3__i_tri_buf_n FE_OFN353_n CTL_N[23] DVSS DVSS DVDD DVDD dout_p
+ sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_2__i_tri_buf_p FE_OFN203_n130 CTL_P[22] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_2__i_tri_buf_n FE_OFN157_n128 CTL_N[22] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_1__i_tri_buf_p FE_OFN203_n130 CTL_P[21] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_1__i_tri_buf_n FE_OFN157_n128 CTL_N[21] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_0__i_tri_buf_p FE_OFN203_n130 CTL_P[20] DVSS DVSS DVDD DVDD
+ dout_n sky130_fd_sc_hs__einvp_2
Xibuf_genblk1_0__i_tri_buf_n FE_OFN157_n128 CTL_N[20] DVSS DVSS DVDD DVDD
+ dout_p sky130_fd_sc_hs__einvp_2
Xibuf_predrv_n0_1 dout_n DVSS DVSS DVDD DVDD n83
+ sky130_fd_sc_hs__clkdlyinv5sd2_1
Xibuf_predrv_n0_0 dout_n DVSS DVSS DVDD DVDD n82
+ sky130_fd_sc_hs__clkdlyinv5sd2_1
Xibuf_predrv_p0_1 dout_p DVSS DVSS DVDD DVDD n77
+ sky130_fd_sc_hs__clkdlyinv5sd2_1
Xibuf_predrv_p0_0 dout_p DVSS DVSS DVDD DVDD n76
+ sky130_fd_sc_hs__clkdlyinv5sd2_1
Xck_I_tri n30 N3 DVSS DVSS DVDD DVDD ck_I sky130_fd_sc_hs__einvn_1
XCTL_N_reg_39_ N290 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD CTL_N[39]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_38_ FE_OFN361_N289 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD
+ CTL_N[38] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_37_ FE_OFN363_N288 FE_OFN218_n119 LTIE_62_HINET DVSS DVSS DVDD DVDD
+ CTL_N[37] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_36_ FE_OFN207_N287 FE_OFN218_n119 LTIE_62_HINET DVSS DVSS DVDD DVDD
+ CTL_N[36] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_35_ FE_OFN362_N286 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD
+ CTL_N[35] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_34_ FE_OFN206_N285 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD
+ CTL_N[34] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_33_ FE_OFN205_N284 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD
+ CTL_N[33] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_32_ FE_OFN214_N283 FE_OFN219_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[32] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_31_ FE_OFN195_N282 FE_OFN218_n119 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_N[31] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_30_ FE_OFN349_N281 FE_OFN218_n119 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_N[30] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_29_ FE_OFN212_N280 FE_OFN218_n119 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_N[29] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_28_ FE_OFN228_N279 FE_OFN218_n119 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_N[28] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_27_ FE_OFN211_N278 FE_OFN218_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[27] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_26_ FE_OFN290_N277 FE_OFN219_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[26] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_25_ FE_OFN308_N276 FE_OFN218_n119 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_N[25] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_24_ FE_OFN343_N275 FE_OFN218_n119 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_N[24] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_23_ FE_OFN346_N274 FE_OFN218_n119 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_N[23] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_22_ FE_OFN355_N273 FE_OFN218_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[22] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_21_ FE_OFN224_N272 FE_OFN219_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[21] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_20_ FE_OFN286_N271 FE_OFN219_n119 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_N[20] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_19_ FE_OFN356_N270 FE_OFN219_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[19] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_18_ N269 FE_OFN219_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD CTL_N[18]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_17_ FE_OFN244_N268 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD
+ CTL_N[17] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_16_ N267 FE_OFN219_n119 LTIE_60_HINET DVSS DVSS DVDD DVDD CTL_N[16]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_15_ N266 FE_OFN218_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD CTL_N[15]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_14_ FE_OFN222_N265 FE_OFN218_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[14] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_13_ FE_OFN221_N264 FE_OFN219_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[13] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_12_ FE_OFN8_N263 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[12] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_11_ FE_OFN220_N262 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[11] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_10_ FE_OFN0_N261 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[10] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_9_ FE_OFN242_N260 FE_OFN218_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[9] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_8_ FE_OFN370_N259 FE_OFN218_n119 LTIE_62_HINET DVSS DVSS DVDD DVDD
+ CTL_N[8] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_7_ N258 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD CTL_N[7]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_6_ N257 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD CTL_N[6]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_5_ FE_OFN240_N256 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[5] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_4_ FE_OFN286_N255 FE_OFN219_n119 LTIE_58_HINET DVSS DVSS DVDD DVDD
+ CTL_N[4] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_3_ FE_OFN239_N254 FE_OFN218_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[3] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_2_ FE_OFN27_N253 FE_OFN218_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[2] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_1_ FE_OFN252_N252 FE_OFN218_n119 LTIE_59_HINET DVSS DVSS DVDD DVDD
+ CTL_N[1] sky130_fd_sc_hs__dlrtp_1
XCTL_N_reg_0_ FE_OFN311_N251 FE_OFN218_n119 LTIE_62_HINET DVSS DVSS DVDD DVDD
+ CTL_N[0] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_39_ FE_OFN201_N485 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD
+ CTL_P[39] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_38_ N484 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD CTL_P[38]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_37_ FE_OFN217_N483 FE_OFN238_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[37] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_36_ FE_OFN235_N482 FE_OFN236_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[36] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_35_ FE_OFN216_N481 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD
+ CTL_P[35] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_34_ N480 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD CTL_P[34]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_33_ FE_OFN331_N479 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD
+ CTL_P[33] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_32_ FE_OFN348_N478 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD
+ CTL_P[32] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_31_ FE_OFN215_N477 FE_OFN238_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[31] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_30_ FE_OFN292_N476 FE_OFN236_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_P[30] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_29_ FE_OFN231_N475 FE_OFN236_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_P[29] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_28_ FE_OFN324_N474 FE_OFN236_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_P[28] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_27_ FE_OFN230_N473 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD
+ CTL_P[27] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_26_ N472 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD CTL_P[26]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_25_ FE_OFN250_N471 FE_OFN236_n113 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_P[25] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_24_ FE_OFN341_N470 FE_OFN236_n113 LTIE_67_HINET DVSS DVSS DVDD DVDD
+ CTL_P[24] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_23_ N469 FE_OFN236_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD CTL_P[23]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_22_ FE_OFN345_N468 FE_OFN236_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_P[22] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_21_ FE_OFN188_N467 FE_OFN236_n113 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_P[21] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_20_ FE_OFN5_N466 FE_OFN236_n113 LTIE_66_HINET DVSS DVSS DVDD DVDD
+ CTL_P[20] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_19_ FE_OFN187_N465 FE_OFN237_n113 LTIE_72_HINET DVSS DVSS DVDD DVDD
+ CTL_P[19] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_18_ FE_OFN287_N464 FE_OFN237_n113 LTIE_79_HINET DVSS DVSS DVDD DVDD
+ CTL_P[18] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_17_ FE_OFN338_N463 FE_OFN237_n113 LTIE_79_HINET DVSS DVSS DVDD DVDD
+ CTL_P[17] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_16_ FE_OFN208_N462 FE_OFN237_n113 LTIE_79_HINET DVSS DVSS DVDD DVDD
+ CTL_P[16] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_15_ FE_OFN307_N461 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD
+ CTL_P[15] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_14_ FE_OFN344_N460 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD
+ CTL_P[14] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_13_ FE_OFN249_N459 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD
+ CTL_P[13] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_12_ N458 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD CTL_P[12]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_11_ FE_OFN248_N457 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD
+ CTL_P[11] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_10_ FE_OFN352_N456 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD
+ CTL_P[10] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_9_ FE_OFN351_N455 FE_OFN238_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[9] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_8_ FE_OFN354_N454 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD
+ CTL_P[8] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_7_ N453 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD CTL_P[7]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_6_ FE_OFN358_N452 FE_OFN237_n113 LTIE_78_HINET DVSS DVSS DVDD DVDD
+ CTL_P[6] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_5_ FE_OFN258_N451 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD
+ CTL_P[5] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_4_ N450 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD CTL_P[4]
+ sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_3_ FE_OFN257_N449 FE_OFN238_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[3] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_2_ FE_OFN265_N448 FE_OFN237_n113 LTIE_74_HINET DVSS DVSS DVDD DVDD
+ CTL_P[2] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_1_ FE_OFN264_N447 FE_OFN237_n113 LTIE_68_HINET DVSS DVSS DVDD DVDD
+ CTL_P[1] sky130_fd_sc_hs__dlrtp_1
XCTL_P_reg_0_ FE_OFN266_N446 FE_OFN237_n113 LTIE_75_HINET DVSS DVSS DVDD DVDD
+ CTL_P[0] sky130_fd_sc_hs__dlrtp_1
Xref_clk_in_buf3_1 ref_clk_ext_n DVSS DVSS DVDD DVDD 1054
+ sky130_fd_sc_hs__inv_4
Xref_clk_in_buf3_0 ref_clk_ext_n DVSS DVSS DVDD DVDD 1055
+ sky130_fd_sc_hs__inv_4
XU189 n112 FE_OFN34_CTL_BUF_P_3 DVSS DVSS DVDD DVDD n110
+ sky130_fd_sc_hs__nand2_1
XU193 n118 FE_OFN22_CTL_BUF_N_3 DVSS DVSS DVDD DVDD n111
+ sky130_fd_sc_hs__nand2_1
XU212 FE_OFN112_pi1_con_2 DVSS DVSS DVDD DVDD n57 sky130_fd_sc_hs__inv_4
XU213 FE_OFN114_pi1_con_1 DVSS DVSS DVDD DVDD n58 sky130_fd_sc_hs__inv_4
XU214 FE_OFN116_pi1_con_0 DVSS DVSS DVDD DVDD n59 sky130_fd_sc_hs__inv_4
XU215 FE_OFN41_osc_en DVSS DVSS DVDD DVDD N3 sky130_fd_sc_hs__clkinv_8
XU251 N266 DVSS DVSS DVDD DVDD n149 sky130_fd_sc_hs__inv_4
XU256 pi1 DVSS DVSS DVDD DVDD n1 sky130_fd_sc_hs__inv_4
XU257 pi3 DVSS DVSS DVDD DVDD n30 sky130_fd_sc_hs__inv_4
XU272 din_reorder[3] DVSS DVSS DVDD DVDD n_48_net__3_ sky130_fd_sc_hs__clkinv_8
XU273 din_reorder[12] DVSS DVSS DVDD DVDD n_48_net__12_ sky130_fd_sc_hs__inv_4
XU274 din_reorder[7] DVSS DVSS DVDD DVDD n_48_net__7_ sky130_fd_sc_hs__clkinv_8
XU275 din_reorder[15] DVSS DVSS DVDD DVDD n_48_net__15_
+ sky130_fd_sc_hs__clkinv_8
XU276 din_reorder[14] DVSS DVSS DVDD DVDD n_48_net__14_ sky130_fd_sc_hs__inv_4
XU277 din_reorder[2] DVSS DVSS DVDD DVDD n_48_net__2_ sky130_fd_sc_hs__inv_4
XU278 din_reorder[6] DVSS DVSS DVDD DVDD n_48_net__6_ sky130_fd_sc_hs__inv_4
XU279 din_reorder[9] DVSS DVSS DVDD DVDD n_48_net__9_ sky130_fd_sc_hs__clkinv_8
XU280 din_reorder[8] DVSS DVSS DVDD DVDD n_48_net__8_ sky130_fd_sc_hs__inv_4
XU281 din_reorder[13] DVSS DVSS DVDD DVDD n_48_net__13_
+ sky130_fd_sc_hs__clkinv_8
XU282 din_reorder[1] DVSS DVSS DVDD DVDD n_48_net__1_ sky130_fd_sc_hs__inv_4
XU283 din_reorder[5] DVSS DVSS DVDD DVDD n_48_net__5_ sky130_fd_sc_hs__clkinv_8
XU284 din_reorder[0] DVSS DVSS DVDD DVDD n_48_net__0_ sky130_fd_sc_hs__inv_4
XU285 din_reorder[10] DVSS DVSS DVDD DVDD n_48_net__10_ sky130_fd_sc_hs__inv_4
XU286 din_reorder[4] DVSS DVSS DVDD DVDD n_48_net__4_ sky130_fd_sc_hs__inv_4
XU287 din_reorder[11] DVSS DVSS DVDD DVDD n_48_net__11_
+ sky130_fd_sc_hs__clkinv_8
XU293 n97 n96 DVSS DVSS DVDD DVDD clk_prbsgen sky130_fd_sc_hs__and2_4
XU303 FE_OFN30_CTL_BUF_P_5 n142 FE_OFN257_N449 DVSS DVSS DVDD DVDD N448
+ sky130_fd_sc_hs__o21bai_2
XU309 FE_OFN30_CTL_BUF_P_5 FE_OFN177_n146 n2650 DVSS DVSS DVDD DVDD N452
+ sky130_fd_sc_hs__o21ai_2
XU312 n217 FE_OFN174_n134 FE_OFN351_N455 DVSS DVSS DVDD DVDD N454
+ sky130_fd_sc_hs__o21bai_2
XU315 FE_OFN174_n134 FE_OFN162_n144 FE_OFN249_N459 DVSS DVSS DVDD DVDD N458
+ sky130_fd_sc_hs__o21bai_2
XU321 FE_OFN175_n136 FE_OFN160_n142 FE_OFN187_N465 DVSS DVSS DVDD DVDD N464
+ sky130_fd_sc_hs__o21bai_2
XU323 FE_OFN176_n136 FE_OFN162_n144 FE_OFN188_N467 DVSS DVSS DVDD DVDD N466
+ sky130_fd_sc_hs__o21bai_2
XU324 FE_OFN176_n136 n146 n135 DVSS DVSS DVDD DVDD N468
+ sky130_fd_sc_hs__o21ai_2
XU330 FE_OFN162_n144 FE_OFN190_n138 FE_OFN231_N475 DVSS DVSS DVDD DVDD N474
+ sky130_fd_sc_hs__o21bai_2
XU331 FE_OFN190_n138 n146 n2620 DVSS DVSS DVDD DVDD N476
+ sky130_fd_sc_hs__o21ai_2
XU337 FE_OFN191_n147 FE_OFN162_n144 FE_OFN217_N483 DVSS DVSS DVDD DVDD N482
+ sky130_fd_sc_hs__o21bai_4
XU338 FE_OFN191_n147 n146 n2590 DVSS DVSS DVDD DVDD N484
+ sky130_fd_sc_hs__o21ai_2
XU340 N258 DVSS DVSS DVDD DVDD n148 sky130_fd_sc_hs__inv_4
XU345 FE_OFN18_CTL_BUF_N_5 n224 FE_OFN252_N252 DVSS DVSS DVDD DVDD N251
+ sky130_fd_sc_hs__o21bai_2
XU347 FE_OFN18_CTL_BUF_N_5 FE_OFN163_n158 FE_OFN239_N254 DVSS DVSS DVDD DVDD
+ N253 sky130_fd_sc_hs__o21bai_2
XU351 FE_OFN18_CTL_BUF_N_5 FE_OFN166_n160 FE_OFN240_N256 DVSS DVSS DVDD DVDD
+ N255 sky130_fd_sc_hs__o21bai_2
XU353 FE_OFN18_CTL_BUF_N_5 n162 n148 DVSS DVSS DVDD DVDD N257
+ sky130_fd_sc_hs__o21ai_2
XU356 n224 FE_OFN178_n150 FE_OFN242_N260 DVSS DVSS DVDD DVDD N259
+ sky130_fd_sc_hs__o21bai_2
XU357 n150 FE_OFN163_n158 FE_OFN220_N262 DVSS DVSS DVDD DVDD N261
+ sky130_fd_sc_hs__o21bai_2
XU360 FE_OFN178_n150 n162 n149 DVSS DVSS DVDD DVDD N265
+ sky130_fd_sc_hs__o21ai_2
XU364 n224 FE_OFN179_n152 FE_OFN244_N268 DVSS DVSS DVDD DVDD N267
+ sky130_fd_sc_hs__o21bai_2
XU365 FE_OFN179_n152 FE_OFN163_n158 FE_OFN356_N270 DVSS DVSS DVDD DVDD N269
+ sky130_fd_sc_hs__o21bai_2
XU367 FE_OFN179_n152 FE_OFN166_n160 FE_OFN224_N272 DVSS DVSS DVDD DVDD N271
+ sky130_fd_sc_hs__o21bai_2
XU368 FE_OFN179_n152 FE_OFN180_n162 n151 DVSS DVSS DVDD DVDD N273
+ sky130_fd_sc_hs__o21ai_2
XU371 n224 FE_OFN192_n154 FE_OFN308_N276 DVSS DVSS DVDD DVDD N275
+ sky130_fd_sc_hs__o21bai_4
XU372 FE_OFN163_n158 FE_OFN192_n154 FE_OFN211_N278 DVSS DVSS DVDD DVDD N277
+ sky130_fd_sc_hs__o21bai_4
XU374 FE_OFN166_n160 FE_OFN192_n154 FE_OFN212_N280 DVSS DVSS DVDD DVDD N279
+ sky130_fd_sc_hs__o21bai_2
XU375 FE_OFN192_n154 FE_OFN180_n162 n2610 DVSS DVSS DVDD DVDD N281
+ sky130_fd_sc_hs__o21ai_2
XU379 FE_OFN193_n163 FE_OFN163_n158 FE_OFN362_N286 DVSS DVSS DVDD DVDD N285
+ sky130_fd_sc_hs__o21bai_4
XU381 FE_OFN193_n163 FE_OFN166_n160 FE_OFN363_N288 DVSS DVSS DVDD DVDD N287
+ sky130_fd_sc_hs__o21bai_2
XU383 n83 n82 DVSS DVSS DVDD DVDD ibuf_inn_buf_0 sky130_fd_sc_hs__and2_2
XU191 FE_OFN143_pi5_con_0 DVSS DVSS DVDD DVDD n181 sky130_fd_sc_hs__inv_4
XU196 FE_OFN142_pi5_con_1 DVSS DVSS DVDD DVDD n183 sky130_fd_sc_hs__inv_4
XU198 FE_OFN141_pi5_con_2 DVSS DVSS DVDD DVDD n185 sky130_fd_sc_hs__inv_4
XU200 FE_OFN139_pi5_con_3 DVSS DVSS DVDD DVDD n187 sky130_fd_sc_hs__inv_4
XU202 FE_OFN138_pi4_con_0 DVSS DVSS DVDD DVDD n189 sky130_fd_sc_hs__inv_4
XU204 FE_OFN137_pi4_con_1 DVSS DVSS DVDD DVDD n191 sky130_fd_sc_hs__inv_4
XU206 FE_OFN136_pi4_con_2 DVSS DVSS DVDD DVDD n193 sky130_fd_sc_hs__inv_4
XU208 FE_OFN135_pi4_con_3 DVSS DVSS DVDD DVDD n195 sky130_fd_sc_hs__inv_4
XU209 FE_OFN134_pi3_con_0 DVSS DVSS DVDD DVDD n196 sky130_fd_sc_hs__inv_4
XU211 FE_OFN132_pi3_con_1 DVSS DVSS DVDD DVDD n198 sky130_fd_sc_hs__inv_4
XU219 FE_OFN129_pi3_con_2 DVSS DVSS DVDD DVDD n200 sky130_fd_sc_hs__inv_4
XU222 FE_OFN127_pi3_con_3 DVSS DVSS DVDD DVDD n202 sky130_fd_sc_hs__inv_4
XU224 FE_OFN125_pi2_con_0 DVSS DVSS DVDD DVDD n204 sky130_fd_sc_hs__inv_4
XU226 FE_OFN122_pi2_con_1 DVSS DVSS DVDD DVDD n206 sky130_fd_sc_hs__inv_4
XU228 FE_OFN120_pi2_con_2 DVSS DVSS DVDD DVDD n208 sky130_fd_sc_hs__inv_4
XU232 FE_OFN118_pi2_con_3 DVSS DVSS DVDD DVDD n210 sky130_fd_sc_hs__clkinv_4
XU234 FE_OFN110_pi1_con_3 DVSS DVSS DVDD DVDD n211 sky130_fd_sc_hs__inv_4
XU240 FE_OFN40_CTL_BUF_P_0 DVSS DVSS DVDD DVDD n217 sky130_fd_sc_hs__clkinv_4
XU244 FE_OFN38_CTL_BUF_P_1 DVSS DVSS DVDD DVDD n219 sky130_fd_sc_hs__clkinv_4
XU296 FE_OFN30_CTL_BUF_P_5 DVSS DVSS DVDD DVDD n223 sky130_fd_sc_hs__clkinv_4
XU298 FE_OFN28_CTL_BUF_N_0 DVSS DVSS DVDD DVDD n224 sky130_fd_sc_hs__inv_8
XU339 FE_OFN26_CTL_BUF_N_1 DVSS DVSS DVDD DVDD n226 sky130_fd_sc_hs__clkinv_4
XU344 FE_OFN24_CTL_BUF_N_2 DVSS DVSS DVDD DVDD n228 sky130_fd_sc_hs__clkinv_4
XU386 FE_OFN18_CTL_BUF_N_5 DVSS DVSS DVDD DVDD n230 sky130_fd_sc_hs__clkinv_4
XU415 FE_OFN201_N485 DVSS DVSS DVDD DVDD n2590 sky130_fd_sc_hs__inv_4
XU417 FE_OFN195_N282 DVSS DVSS DVDD DVDD n2610 sky130_fd_sc_hs__inv_4
Xck_IB_tri pi3 N3 DVSS DVSS DVDD DVDD ck_IB sky130_fd_sc_hs__einvn_4
Xck_Q_tri n1 N3 DVSS DVSS DVDD DVDD ck_Q sky130_fd_sc_hs__einvn_8
Xck_QB_tri pi1 N3 DVSS DVSS DVDD DVDD ck_QB sky130_fd_sc_hs__einvn_2
XU329 FE_OFN161_n143 FE_OFN190_n138 n2620 DVSS DVSS DVDD DVDD N475
+ sky130_fd_sc_hs__o21ai_2
XU217 FE_OFN34_CTL_BUF_P_3 n112 DVSS DVSS DVDD DVDD n147
+ sky130_fd_sc_hs__or2b_2
XU247 FE_OFN175_n136 FE_OFN34_CTL_BUF_P_3 DVSS DVSS DVDD DVDD n138
+ sky130_fd_sc_hs__or2b_2
XU230 FE_OFN22_CTL_BUF_N_3 n118 DVSS DVSS DVDD DVDD n163
+ sky130_fd_sc_hs__or2b_4
XU254 n152 FE_OFN22_CTL_BUF_N_3 DVSS DVSS DVDD DVDD n154
+ sky130_fd_sc_hs__or2b_2
XU318 n221 FE_OFN175_n136 n135 DVSS DVSS DVDD DVDD N465
+ sky130_fd_sc_hs__o21ai_2
XU297 FE_OFN30_CTL_BUF_P_5 n221 n2650 DVSS DVSS DVDD DVDD N449
+ sky130_fd_sc_hs__o21ai_2
XU350 FE_OFN28_CTL_BUF_N_0 FE_OFN24_CTL_BUF_N_2 DVSS DVSS DVDD DVDD n160
+ sky130_fd_sc_hs__nand2_2
XU346 FE_OFN28_CTL_BUF_N_0 FE_OFN26_CTL_BUF_N_1 DVSS DVSS DVDD DVDD n158
+ sky130_fd_sc_hs__nand2_2
XU246 n2640 FE_OFN174_n134 DVSS DVSS DVDD DVDD N453 sky130_fd_sc_hs__nand2_2
XU316 FE_OFN174_n134 FE_OFN177_n146 n2640 DVSS DVSS DVDD DVDD N460
+ sky130_fd_sc_hs__o21ai_2
XU233 FE_OFN18_CTL_BUF_N_5 FE_OFN209_n2610 DVSS DVSS DVDD DVDD n119
+ sky130_fd_sc_hs__nand2_2
XU308 FE_OFN161_n143 FE_OFN40_CTL_BUF_P_0 DVSS DVSS DVDD DVDD n146
+ sky130_fd_sc_hs__or2b_4
XU220 FE_OFN30_CTL_BUF_P_5 n2620 DVSS DVSS DVDD DVDD n113
+ sky130_fd_sc_hs__nand2_2
XU314 FE_OFN174_n134 FE_OFN161_n143 n2640 DVSS DVSS DVDD DVDD N459
+ sky130_fd_sc_hs__o21ai_2
XU336 FE_OFN191_n147 FE_OFN161_n143 n2590 DVSS DVSS DVDD DVDD N483
+ sky130_fd_sc_hs__o21ai_2
XU366 FE_OFN179_n152 FE_OFN165_n159 n151 DVSS DVSS DVDD DVDD N272
+ sky130_fd_sc_hs__o21ai_2
XU322 FE_OFN176_n136 FE_OFN161_n143 n135 DVSS DVSS DVDD DVDD N467
+ sky130_fd_sc_hs__o21ai_2
XU349 FE_OFN18_CTL_BUF_N_5 FE_OFN164_n159 n148 DVSS DVSS DVDD DVDD N256
+ sky130_fd_sc_hs__o21ai_2
XU358 FE_OFN357_n150 FE_OFN164_n159 n149 DVSS DVSS DVDD DVDD N264
+ sky130_fd_sc_hs__o21ai_2
XU373 FE_OFN165_n159 FE_OFN192_n154 n2610 DVSS DVSS DVDD DVDD N280
+ sky130_fd_sc_hs__o21ai_2
XU243 n2620 FE_OFN175_n136 DVSS DVSS DVDD DVDD N461 sky130_fd_sc_hs__nand2_2
XU370 n226 FE_OFN192_n154 FE_OFN211_N278 DVSS DVSS DVDD DVDD N276
+ sky130_fd_sc_hs__o21bai_2
XU326 n219 FE_OFN190_n138 FE_OFN230_N473 DVSS DVSS DVDD DVDD N471
+ sky130_fd_sc_hs__o21bai_2
XU231 FE_OFN194_n2670 FE_OFN193_n163 DVSS DVSS DVDD DVDD N282
+ sky130_fd_sc_hs__nand2_2
XU299 FE_OFN30_CTL_BUF_P_5 n219 FE_OFN257_N449 DVSS DVSS DVDD DVDD N447
+ sky130_fd_sc_hs__o21bai_2
XU343 FE_OFN18_CTL_BUF_N_5 n226 FE_OFN239_N254 DVSS DVSS DVDD DVDD N252
+ sky130_fd_sc_hs__o21bai_2
XU311 n219 FE_OFN174_n134 FE_OFN248_N457 DVSS DVSS DVDD DVDD N455
+ sky130_fd_sc_hs__o21bai_2
XU355 n226 FE_OFN178_n150 FE_OFN220_N262 DVSS DVSS DVDD DVDD N260
+ sky130_fd_sc_hs__o21bai_2
XU376 n228 FE_OFN193_n163 FE_OFN194_n2670 DVSS DVSS DVDD DVDD N286
+ sky130_fd_sc_hs__o21ai_2
XU248 n2620 FE_OFN190_n138 DVSS DVSS DVDD DVDD N469 sky130_fd_sc_hs__nand2_2
XU363 n226 FE_OFN179_n152 FE_OFN356_N270 DVSS DVSS DVDD DVDD N268
+ sky130_fd_sc_hs__o21bai_2
XU380 FE_OFN193_n163 FE_OFN165_n159 FE_OFN194_n2670 DVSS DVSS DVDD DVDD N288
+ sky130_fd_sc_hs__o21ai_2
XU382 n163 FE_OFN180_n162 FE_OFN194_n2670 DVSS DVSS DVDD DVDD N289
+ sky130_fd_sc_hs__o21ai_2
XU305 FE_OFN30_CTL_BUF_P_5 FE_OFN161_n143 n2650 DVSS DVSS DVDD DVDD N451
+ sky130_fd_sc_hs__o21ai_4
XU319 n219 FE_OFN175_n136 FE_OFN187_N465 DVSS DVSS DVDD DVDD N463
+ sky130_fd_sc_hs__o21bai_2
XU310 n221 FE_OFN174_n134 n2640 DVSS DVSS DVDD DVDD N457
+ sky130_fd_sc_hs__o21ai_2
XU341 FE_OFN18_CTL_BUF_N_5 n228 n148 DVSS DVSS DVDD DVDD N254
+ sky130_fd_sc_hs__o21ai_2
XU354 n228 FE_OFN178_n150 n149 DVSS DVSS DVDD DVDD N262
+ sky130_fd_sc_hs__o21ai_2
XU304 FE_OFN36_CTL_BUF_P_2 FE_OFN38_CTL_BUF_P_1 DVSS DVSS DVDD DVDD n143
+ sky130_fd_sc_hs__nand2_2
XU348 FE_OFN24_CTL_BUF_N_2 FE_OFN26_CTL_BUF_N_1 DVSS DVSS DVDD DVDD n159
+ sky130_fd_sc_hs__nand2_8
XU249 FE_OFN20_CTL_BUF_N_4 n230 DVSS DVSS DVDD DVDD n152
+ sky130_fd_sc_hs__nand2_8
XU334 n217 FE_OFN191_n147 FE_OFN331_N479 DVSS DVSS DVDD DVDD N478
+ sky130_fd_sc_hs__o21bai_2
XU307 FE_OFN30_CTL_BUF_P_5 FE_OFN162_n144 FE_OFN258_N451 DVSS DVSS DVDD DVDD
+ N450 sky130_fd_sc_hs__o21bai_2
XU301 FE_OFN30_CTL_BUF_P_5 n217 FE_OFN264_N447 DVSS DVSS DVDD DVDD N446
+ sky130_fd_sc_hs__o21bai_2
XU320 n217 FE_OFN175_n136 FE_OFN338_N463 DVSS DVSS DVDD DVDD N462
+ sky130_fd_sc_hs__o21bai_2
XU352 n159 FE_OFN28_CTL_BUF_N_0 DVSS DVSS DVDD DVDD n162
+ sky130_fd_sc_hs__or2b_4
XU362 n228 FE_OFN179_n152 n151 DVSS DVSS DVDD DVDD N270
+ sky130_fd_sc_hs__o21ai_2
XU242 FE_OFN32_CTL_BUF_P_4 n223 DVSS DVSS DVDD DVDD n136
+ sky130_fd_sc_hs__nand2_2
XU253 n149 FE_OFN178_n150 DVSS DVSS DVDD DVDD N258 sky130_fd_sc_hs__nand2_2
XU255 n2610 FE_OFN192_n154 DVSS DVSS DVDD DVDD N274 sky130_fd_sc_hs__nand2_2
XU333 n219 n147 FE_OFN216_N481 DVSS DVSS DVDD DVDD N479
+ sky130_fd_sc_hs__o21bai_2
XU327 n217 FE_OFN190_n138 FE_OFN250_N471 DVSS DVSS DVDD DVDD N470
+ sky130_fd_sc_hs__o21bai_2
XU245 FE_OFN34_CTL_BUF_P_3 n223 DVSS DVSS DVDD DVDD n134
+ sky130_fd_sc_hs__nand2_2
XU325 n221 FE_OFN190_n138 n2620 DVSS DVSS DVDD DVDD N473
+ sky130_fd_sc_hs__o21ai_2
XU377 n226 FE_OFN193_n163 FE_OFN362_N286 DVSS DVSS DVDD DVDD N284
+ sky130_fd_sc_hs__o21bai_2
XU252 FE_OFN22_CTL_BUF_N_3 n230 DVSS DVSS DVDD DVDD n150
+ sky130_fd_sc_hs__nand2_8
XU218 n2590 FE_OFN191_n147 DVSS DVSS DVDD DVDD N477 sky130_fd_sc_hs__nand2_2
XU332 n221 FE_OFN191_n147 n2590 DVSS DVSS DVDD DVDD N481
+ sky130_fd_sc_hs__o21ai_2
XU192 FE_OFN20_CTL_BUF_N_4 n230 DVSS DVSS DVDD DVDD n118
+ sky130_fd_sc_hs__nor2_4
XU271 FE_OFN36_CTL_BUF_P_2 DVSS DVSS DVDD DVDD n221 sky130_fd_sc_hs__clkinv_4
XU250 FE_OFN209_n2610 FE_OFN179_n152 DVSS DVSS DVDD DVDD N266
+ sky130_fd_sc_hs__nand2_2
XU418 FE_OFN215_N477 DVSS DVSS DVDD DVDD n2620 sky130_fd_sc_hs__clkinv_4
XU369 n228 FE_OFN192_n154 n2610 DVSS DVSS DVDD DVDD N278
+ sky130_fd_sc_hs__o21ai_2
XU188 FE_OFN32_CTL_BUF_P_4 n223 DVSS DVSS DVDD DVDD n112
+ sky130_fd_sc_hs__nor2_4
XU378 n224 FE_OFN193_n163 FE_OFN205_N284 DVSS DVSS DVDD DVDD N283
+ sky130_fd_sc_hs__o21bai_2
XU306 FE_OFN40_CTL_BUF_P_0 FE_OFN36_CTL_BUF_P_2 DVSS DVSS DVDD DVDD n144
+ sky130_fd_sc_hs__nand2_2
XU302 FE_OFN40_CTL_BUF_P_0 FE_OFN38_CTL_BUF_P_1 DVSS DVSS DVDD DVDD n142
+ sky130_fd_sc_hs__nand2_8
XU313 FE_OFN174_n134 FE_OFN160_n142 FE_OFN248_N457 DVSS DVSS DVDD DVDD N456
+ sky130_fd_sc_hs__o21bai_2
XU335 FE_OFN191_n147 FE_OFN160_n142 FE_OFN216_N481 DVSS DVSS DVDD DVDD N480
+ sky130_fd_sc_hs__o21bai_2
XU359 n150 n160 FE_OFN221_N264 DVSS DVSS DVDD DVDD N263
+ sky130_fd_sc_hs__o21bai_2
XU190 FE_OFN40_CTL_BUF_P_0 FE_OFN36_CTL_BUF_P_2 FE_OFN38_CTL_BUF_P_1 n110 DVSS
+ DVSS DVDD DVDD N485 sky130_fd_sc_hs__nor4_2
XU328 n142 FE_OFN190_n138 FE_OFN230_N473 DVSS DVSS DVDD DVDD N472
+ sky130_fd_sc_hs__o21bai_2
XU410 FE_OFN28_CTL_BUF_N_0 FE_OFN24_CTL_BUF_N_2 FE_OFN26_CTL_BUF_N_1 n111 DVSS
+ DVSS DVDD DVDD n2670 sky130_fd_sc_hs__or4_2
XU411 FE_OFN194_n2670 DVSS DVSS DVDD DVDD N290 sky130_fd_sc_hs__inv_4
XU486 ref_clk_ext_p DVSS DVSS DVDD DVDD 1056 sky130_fd_sc_hs__clkbuf_4
.ENDS

.SUBCKT SNPS_CLOCK_GATE_HIGH_prbs_generator_syn CLK EN ENCLK TE DVDD DVSS
XLTIE DVSS DVSS DVDD DVDD 1000 LTIE_LONET sky130_fd_sc_hs__conb_1
Xlatch CLK EN LTIE_LONET DVSS DVSS DVDD DVDD ENCLK sky130_fd_sc_hs__sdlclkp_2
.ENDS

.SUBCKT prbs_generator_syn clk rst cke init_val[31] init_val[30] init_val[29]
+ init_val[28] init_val[27] init_val[26] init_val[25] init_val[24] init_val[23]
+ init_val[22] init_val[21] init_val[20] init_val[19] init_val[18] init_val[17]
+ init_val[16] init_val[15] init_val[14] init_val[13] init_val[12] init_val[11]
+ init_val[10] init_val[9] init_val[8] init_val[7] init_val[6] init_val[5]
+ init_val[4] init_val[3] init_val[2] init_val[1] init_val[0] eqn[31] eqn[30]
+ eqn[29] eqn[28] eqn[27] eqn[26] eqn[25] eqn[24] eqn[23] eqn[22] eqn[21]
+ eqn[20] eqn[19] eqn[18] eqn[17] eqn[16] eqn[15] eqn[14] eqn[13] eqn[12]
+ eqn[11] eqn[10] eqn[9] eqn[8] eqn[7] eqn[6] eqn[5] eqn[4] eqn[3] eqn[2]
+ eqn[1] eqn[0] inj_err inv_chicken[1] inv_chicken[0] out DVSS DVDD
XCTS_ccl_a_buf_00003 CTS_2 DVSS DVSS DVDD DVDD CTS_1 sky130_fd_sc_hs__clkbuf_16
Xclk_gate_inj_err_mem_reg_3_ clk net118 CTS_2 1000 DVDD DVSS
+ SNPS_CLOCK_GATE_HIGH_prbs_generator_syn
XU2 rst N37 DVSS DVSS DVDD DVDD n1 sky130_fd_sc_hs__nor2b_1
XU3 rst inj_err_mem[2] DVSS DVSS DVDD DVDD n2 sky130_fd_sc_hs__nor2b_1
XU4 rst inj_err_mem[1] DVSS DVSS DVDD DVDD n35 sky130_fd_sc_hs__nor2b_1
XU5 rst inj_err_mem[0] DVSS DVSS DVDD DVDD n40 sky130_fd_sc_hs__nor2b_1
XU6 rst inj_err DVSS DVSS DVDD DVDD n50 sky130_fd_sc_hs__nor2b_1
Xout_reg_reg CTS_1 n1 DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__dfxtp_4
Xinj_err_mem_reg_0_ CTS_1 n50 DVSS DVSS DVDD DVDD inj_err_mem[0]
+ sky130_fd_sc_hs__dfxtp_4
Xinj_err_mem_reg_1_ CTS_1 n40 DVSS DVSS DVDD DVDD inj_err_mem[1]
+ sky130_fd_sc_hs__dfxtp_4
Xinj_err_mem_reg_3_ CTS_1 n2 DVSS DVSS DVDD DVDD inj_err_mem[3]
+ sky130_fd_sc_hs__dfxtp_4
Xinj_err_mem_reg_2_ CTS_1 n35 DVSS DVSS DVDD DVDD inj_err_mem[2]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_0_ CTS_1 N3 DVSS DVSS DVDD DVDD prbs_state[0]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_2_ CTS_1 N5 DVSS DVSS DVDD DVDD prbs_state[2]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_4_ CTS_1 N7 DVSS DVSS DVDD DVDD prbs_state[4]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_5_ CTS_1 N8 DVSS DVSS DVDD DVDD prbs_state[5]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_6_ CTS_1 N9 DVSS DVSS DVDD DVDD prbs_state[6]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_7_ CTS_1 N10 DVSS DVSS DVDD DVDD prbs_state[7]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_8_ CTS_1 N11 DVSS DVSS DVDD DVDD prbs_state[8]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_9_ CTS_1 N12 DVSS DVSS DVDD DVDD prbs_state[9]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_10_ CTS_1 N13 DVSS DVSS DVDD DVDD prbs_state[10]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_11_ CTS_1 N14 DVSS DVSS DVDD DVDD prbs_state[11]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_12_ CTS_1 N15 DVSS DVSS DVDD DVDD prbs_state[12]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_13_ CTS_1 N16 DVSS DVSS DVDD DVDD prbs_state[13]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_14_ CTS_1 N17 DVSS DVSS DVDD DVDD prbs_state[14]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_15_ CTS_1 N18 DVSS DVSS DVDD DVDD prbs_state[15]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_17_ CTS_1 N20 DVSS DVSS DVDD DVDD prbs_state[17]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_20_ CTS_1 N23 DVSS DVSS DVDD DVDD prbs_state[20]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_21_ CTS_1 N24 DVSS DVSS DVDD DVDD prbs_state[21]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_22_ CTS_1 N25 DVSS DVSS DVDD DVDD prbs_state[22]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_23_ CTS_1 N26 DVSS DVSS DVDD DVDD prbs_state[23]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_24_ CTS_1 N27 DVSS DVSS DVDD DVDD prbs_state[24]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_25_ CTS_1 N28 DVSS DVSS DVDD DVDD prbs_state[25]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_26_ CTS_1 N29 DVSS DVSS DVDD DVDD prbs_state[26]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_28_ CTS_1 N31 DVSS DVSS DVDD DVDD prbs_state[28]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_29_ CTS_1 N32 DVSS DVSS DVDD DVDD prbs_state[29]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_30_ CTS_1 N33 DVSS DVSS DVDD DVDD prbs_state[30]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_31_ CTS_1 N34 DVSS DVSS DVDD DVDD prbs_state[31]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_1_ CTS_1 N4 DVSS DVSS DVDD DVDD prbs_state[1]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_3_ CTS_1 N6 DVSS DVSS DVDD DVDD prbs_state[3]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_16_ CTS_1 N19 DVSS DVSS DVDD DVDD prbs_state[16]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_18_ CTS_1 N21 DVSS DVSS DVDD DVDD prbs_state[18]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_19_ CTS_1 N22 DVSS DVSS DVDD DVDD prbs_state[19]
+ sky130_fd_sc_hs__dfxtp_4
Xprbs_state_reg_27_ CTS_1 N30 DVSS DVSS DVDD DVDD prbs_state[27]
+ sky130_fd_sc_hs__dfxtp_4
XU109 rst cke DVSS DVSS DVDD DVDD net118 sky130_fd_sc_hs__or2_1
XU111 inj_err_mem[3] inj_err_mem[2] DVSS DVSS DVDD DVDD n74
+ sky130_fd_sc_hs__nor2b_1
XU112 prbs_state[31] inv_chicken[1] DVSS DVSS DVDD DVDD n73
+ sky130_fd_sc_hs__xnor2_1
XU113 n74 n73 DVSS DVSS DVDD DVDD N37 sky130_fd_sc_hs__xnor2_1
XU117 eqn[14] prbs_state[14] DVSS DVSS DVDD DVDD n77 sky130_fd_sc_hs__nand2_1
XU118 eqn[29] prbs_state[29] DVSS DVSS DVDD DVDD n76 sky130_fd_sc_hs__nand2_1
XU119 n77 n76 DVSS DVSS DVDD DVDD n85 sky130_fd_sc_hs__xnor2_1
XU120 eqn[26] prbs_state[26] DVSS DVSS DVDD DVDD n79 sky130_fd_sc_hs__nand2_1
XU121 eqn[10] prbs_state[10] DVSS DVSS DVDD DVDD n78 sky130_fd_sc_hs__nand2_1
XU122 n79 n78 DVSS DVSS DVDD DVDD n83 sky130_fd_sc_hs__xnor2_1
XU123 eqn[31] prbs_state[31] DVSS DVSS DVDD DVDD n81 sky130_fd_sc_hs__nand2_2
XU124 eqn[25] prbs_state[25] DVSS DVSS DVDD DVDD n80 sky130_fd_sc_hs__nand2_2
XU125 n81 n80 DVSS DVSS DVDD DVDD n82 sky130_fd_sc_hs__xnor2_1
XU126 n83 n82 DVSS DVSS DVDD DVDD n84 sky130_fd_sc_hs__xnor2_1
XU127 n85 n84 DVSS DVSS DVDD DVDD n138 sky130_fd_sc_hs__xnor2_1
XU128 eqn[11] prbs_state[11] DVSS DVSS DVDD DVDD n87 sky130_fd_sc_hs__nand2_2
XU129 eqn[12] prbs_state[12] DVSS DVSS DVDD DVDD n86 sky130_fd_sc_hs__nand2_1
XU130 n87 n86 DVSS DVSS DVDD DVDD n95 sky130_fd_sc_hs__xnor2_1
XU131 eqn[8] prbs_state[8] DVSS DVSS DVDD DVDD n89 sky130_fd_sc_hs__nand2_1
XU132 eqn[5] prbs_state[5] DVSS DVSS DVDD DVDD n88 sky130_fd_sc_hs__nand2_1
XU133 n89 n88 DVSS DVSS DVDD DVDD n93 sky130_fd_sc_hs__xnor2_1
XU134 eqn[9] prbs_state[9] DVSS DVSS DVDD DVDD n91 sky130_fd_sc_hs__nand2_1
XU135 eqn[4] prbs_state[4] DVSS DVSS DVDD DVDD n90 sky130_fd_sc_hs__nand2_1
XU136 n91 n90 DVSS DVSS DVDD DVDD n92 sky130_fd_sc_hs__xnor2_1
XU137 n93 n92 DVSS DVSS DVDD DVDD n94 sky130_fd_sc_hs__xnor2_1
XU138 n95 n94 DVSS DVSS DVDD DVDD n132 sky130_fd_sc_hs__xnor2_1
XU139 eqn[23] prbs_state[23] DVSS DVSS DVDD DVDD n97 sky130_fd_sc_hs__nand2_1
XU140 eqn[24] prbs_state[24] DVSS DVSS DVDD DVDD n96 sky130_fd_sc_hs__nand2_1
XU141 n97 n96 DVSS DVSS DVDD DVDD n105 sky130_fd_sc_hs__xnor2_1
XU142 eqn[6] prbs_state[6] DVSS DVSS DVDD DVDD n99 sky130_fd_sc_hs__nand2_1
XU143 eqn[21] prbs_state[21] DVSS DVSS DVDD DVDD n98 sky130_fd_sc_hs__nand2_1
XU144 n99 n98 DVSS DVSS DVDD DVDD n103 sky130_fd_sc_hs__xnor2_1
XU145 eqn[28] prbs_state[28] DVSS DVSS DVDD DVDD n101 sky130_fd_sc_hs__nand2_1
XU146 eqn[22] prbs_state[22] DVSS DVSS DVDD DVDD n100 sky130_fd_sc_hs__nand2_1
XU147 n101 n100 DVSS DVSS DVDD DVDD n102 sky130_fd_sc_hs__xnor2_1
XU148 n103 n102 DVSS DVSS DVDD DVDD n104 sky130_fd_sc_hs__xnor2_1
XU149 n105 n104 DVSS DVSS DVDD DVDD n126 sky130_fd_sc_hs__xnor2_1
XU150 eqn[17] prbs_state[17] DVSS DVSS DVDD DVDD n107 sky130_fd_sc_hs__nand2_1
XU151 eqn[20] prbs_state[20] DVSS DVSS DVDD DVDD n106 sky130_fd_sc_hs__nand2_1
XU152 n107 n106 DVSS DVSS DVDD DVDD n120 sky130_fd_sc_hs__xnor2_1
XU153 eqn[27] prbs_state[27] DVSS DVSS DVDD DVDD n109 sky130_fd_sc_hs__nand2_1
XU154 eqn[1] prbs_state[1] DVSS DVSS DVDD DVDD n108 sky130_fd_sc_hs__nand2_1
XU155 n109 n108 DVSS DVSS DVDD DVDD n114 sky130_fd_sc_hs__xnor2_1
XU156 eqn[18] prbs_state[18] DVSS DVSS DVDD DVDD n111 sky130_fd_sc_hs__nand2_1
XU157 eqn[19] prbs_state[19] DVSS DVSS DVDD DVDD n110 sky130_fd_sc_hs__nand2_1
XU158 n111 n110 DVSS DVSS DVDD DVDD n112 sky130_fd_sc_hs__xnor2_1
XU159 inv_chicken[0] n112 DVSS DVSS DVDD DVDD n113 sky130_fd_sc_hs__xnor2_1
XU160 n114 n113 DVSS DVSS DVDD DVDD n118 sky130_fd_sc_hs__xnor2_1
XU161 eqn[16] prbs_state[16] DVSS DVSS DVDD DVDD n116 sky130_fd_sc_hs__nand2_1
XU162 eqn[3] prbs_state[3] DVSS DVSS DVDD DVDD n115 sky130_fd_sc_hs__nand2_1
XU163 n116 n115 DVSS DVSS DVDD DVDD n117 sky130_fd_sc_hs__xnor2_1
XU164 n118 n117 DVSS DVSS DVDD DVDD n119 sky130_fd_sc_hs__xnor2_1
XU165 n120 n119 DVSS DVSS DVDD DVDD n124 sky130_fd_sc_hs__xnor2_1
XU166 eqn[7] prbs_state[7] DVSS DVSS DVDD DVDD n122 sky130_fd_sc_hs__nand2_1
XU167 eqn[15] prbs_state[15] DVSS DVSS DVDD DVDD n121 sky130_fd_sc_hs__nand2_1
XU168 n122 n121 DVSS DVSS DVDD DVDD n123 sky130_fd_sc_hs__xnor2_1
XU169 n124 n123 DVSS DVSS DVDD DVDD n125 sky130_fd_sc_hs__xnor2_1
XU170 n126 n125 DVSS DVSS DVDD DVDD n130 sky130_fd_sc_hs__xnor2_1
XU171 eqn[0] prbs_state[0] DVSS DVSS DVDD DVDD n128 sky130_fd_sc_hs__nand2_1
XU172 eqn[30] prbs_state[30] DVSS DVSS DVDD DVDD n127 sky130_fd_sc_hs__nand2_1
XU173 n128 n127 DVSS DVSS DVDD DVDD n129 sky130_fd_sc_hs__xnor2_1
XU174 n130 n129 DVSS DVSS DVDD DVDD n131 sky130_fd_sc_hs__xnor2_1
XU175 n132 n131 DVSS DVSS DVDD DVDD n136 sky130_fd_sc_hs__xnor2_1
XU176 eqn[13] prbs_state[13] DVSS DVSS DVDD DVDD n134 sky130_fd_sc_hs__nand2_1
XU177 eqn[2] prbs_state[2] DVSS DVSS DVDD DVDD n133 sky130_fd_sc_hs__nand2_1
XU178 n134 n133 DVSS DVSS DVDD DVDD n135 sky130_fd_sc_hs__xnor2_1
XU179 n136 n135 DVSS DVSS DVDD DVDD n137 sky130_fd_sc_hs__xnor2_1
XU180 n138 n137 DVSS DVSS DVDD DVDD n139 sky130_fd_sc_hs__xnor2_1
XU181 rst init_val[0] n75 n139 DVSS DVSS DVDD DVDD N3 sky130_fd_sc_hs__a22o_1
XU182 rst init_val[1] n75 prbs_state[0] DVSS DVSS DVDD DVDD N4
+ sky130_fd_sc_hs__a22o_1
XU183 rst init_val[2] n75 prbs_state[1] DVSS DVSS DVDD DVDD N5
+ sky130_fd_sc_hs__a22o_1
XU184 rst init_val[3] n75 prbs_state[2] DVSS DVSS DVDD DVDD N6
+ sky130_fd_sc_hs__a22o_1
XU185 rst init_val[4] n75 prbs_state[3] DVSS DVSS DVDD DVDD N7
+ sky130_fd_sc_hs__a22o_1
XU186 rst init_val[5] n75 prbs_state[4] DVSS DVSS DVDD DVDD N8
+ sky130_fd_sc_hs__a22o_1
XU187 rst init_val[6] n75 prbs_state[5] DVSS DVSS DVDD DVDD N9
+ sky130_fd_sc_hs__a22o_1
XU188 rst init_val[7] n75 prbs_state[6] DVSS DVSS DVDD DVDD N10
+ sky130_fd_sc_hs__a22o_1
XU189 rst init_val[8] n75 prbs_state[7] DVSS DVSS DVDD DVDD N11
+ sky130_fd_sc_hs__a22o_1
XU190 rst init_val[9] n75 prbs_state[8] DVSS DVSS DVDD DVDD N12
+ sky130_fd_sc_hs__a22o_1
XU191 rst init_val[10] n75 prbs_state[9] DVSS DVSS DVDD DVDD N13
+ sky130_fd_sc_hs__a22o_1
XU192 rst init_val[11] n75 prbs_state[10] DVSS DVSS DVDD DVDD N14
+ sky130_fd_sc_hs__a22o_1
XU194 rst init_val[12] n75 prbs_state[11] DVSS DVSS DVDD DVDD N15
+ sky130_fd_sc_hs__a22o_1
XU195 rst init_val[13] n75 prbs_state[12] DVSS DVSS DVDD DVDD N16
+ sky130_fd_sc_hs__a22o_1
XU196 rst init_val[14] n75 prbs_state[13] DVSS DVSS DVDD DVDD N17
+ sky130_fd_sc_hs__a22o_1
XU197 rst init_val[15] n75 prbs_state[14] DVSS DVSS DVDD DVDD N18
+ sky130_fd_sc_hs__a22o_1
XU198 rst init_val[16] n75 prbs_state[15] DVSS DVSS DVDD DVDD N19
+ sky130_fd_sc_hs__a22o_1
XU199 rst init_val[17] n75 prbs_state[16] DVSS DVSS DVDD DVDD N20
+ sky130_fd_sc_hs__a22o_1
XU200 rst init_val[18] n75 prbs_state[17] DVSS DVSS DVDD DVDD N21
+ sky130_fd_sc_hs__a22o_1
XU201 rst init_val[19] n75 prbs_state[18] DVSS DVSS DVDD DVDD N22
+ sky130_fd_sc_hs__a22o_1
XU202 rst init_val[20] n75 prbs_state[19] DVSS DVSS DVDD DVDD N23
+ sky130_fd_sc_hs__a22o_1
XU203 rst init_val[21] n75 prbs_state[20] DVSS DVSS DVDD DVDD N24
+ sky130_fd_sc_hs__a22o_1
XU204 rst init_val[22] n75 prbs_state[21] DVSS DVSS DVDD DVDD N25
+ sky130_fd_sc_hs__a22o_1
XU205 rst init_val[23] n75 prbs_state[22] DVSS DVSS DVDD DVDD N26
+ sky130_fd_sc_hs__a22o_1
XU207 rst init_val[24] n75 prbs_state[23] DVSS DVSS DVDD DVDD N27
+ sky130_fd_sc_hs__a22o_1
XU208 rst init_val[25] n75 prbs_state[24] DVSS DVSS DVDD DVDD N28
+ sky130_fd_sc_hs__a22o_1
XU209 rst init_val[26] n75 prbs_state[25] DVSS DVSS DVDD DVDD N29
+ sky130_fd_sc_hs__a22o_1
XU210 rst init_val[27] n75 prbs_state[26] DVSS DVSS DVDD DVDD N30
+ sky130_fd_sc_hs__a22o_1
XU211 rst init_val[28] n75 prbs_state[27] DVSS DVSS DVDD DVDD N31
+ sky130_fd_sc_hs__a22o_1
XU212 rst init_val[29] n75 prbs_state[28] DVSS DVSS DVDD DVDD N32
+ sky130_fd_sc_hs__a22o_1
XU213 rst init_val[30] n75 prbs_state[29] DVSS DVSS DVDD DVDD N33
+ sky130_fd_sc_hs__a22o_1
XU214 rst init_val[31] n75 prbs_state[30] DVSS DVSS DVDD DVDD N34
+ sky130_fd_sc_hs__a22o_1
XU114 rst cke DVSS DVSS DVDD DVDD n75 sky130_fd_sc_hs__and2b_2
.ENDS

.SUBCKT div_b2_1 clkin rst clkout CTS DVDD DVSS
XU1 rst DVSS DVSS DVDD DVDD n1 sky130_fd_sc_hs__clkinv_2
Xff_i_Q_reg clkin n_0_net_ n1 DVSS DVSS DVDD DVDD clkout
+ sky130_fd_sc_hs__dfrtp_4
XU2 CTS DVSS DVSS DVDD DVDD n_0_net_ sky130_fd_sc_hs__inv_4
.ENDS

.SUBCKT div_b2_0 clkin rst clkout DVDD DVSS
XU1 rst DVSS DVSS DVDD DVDD n2 sky130_fd_sc_hs__inv_4
Xff_i_Q_reg clkin n_0_net_ n2 DVSS DVSS DVDD DVDD clkout
+ sky130_fd_sc_hs__dfrtp_4
XU2 clkout DVSS DVSS DVDD DVDD n_0_net_ sky130_fd_sc_hs__inv_4
.ENDS

.SUBCKT hr_16t4_mux_top clk din[15] din[14] din[13] din[12] din[11] din[10]
+ din[9] din[8] din[7] din[6] din[5] din[4] din[3] din[2] din[1] din[0] rst
+ clk_prbs dout[3] dout[2] dout[1] dout[0] DVSS DVDD
XFE_PHC15_din_13 din[13] DVSS DVSS DVDD DVDD FE_PHN15_din_13
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC14_din_11 din[11] DVSS DVSS DVDD DVDD FE_PHN14_din_11
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC13_din_10 din[10] DVSS DVSS DVDD DVDD FE_PHN13_din_10
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC12_din_4 din[4] DVSS DVSS DVDD DVDD FE_PHN12_din_4
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC11_din_14 din[14] DVSS DVSS DVDD DVDD FE_PHN11_din_14
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC10_din_0 din[0] DVSS DVSS DVDD DVDD FE_PHN10_din_0
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC9_din_15 din[15] DVSS DVSS DVDD DVDD FE_PHN9_din_15
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC8_din_5 din[5] DVSS DVSS DVDD DVDD FE_PHN8_din_5
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC7_din_12 din[12] DVSS DVSS DVDD DVDD FE_PHN7_din_12
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC6_din_1 din[1] DVSS DVSS DVDD DVDD FE_PHN6_din_1
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC5_din_3 din[3] DVSS DVSS DVDD DVDD FE_PHN5_din_3
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC4_din_6 din[6] DVSS DVSS DVDD DVDD FE_PHN4_din_6
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC3_din_2 din[2] DVSS DVSS DVDD DVDD FE_PHN3_din_2
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC2_din_8 din[8] DVSS DVSS DVDD DVDD FE_PHN2_din_8
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC1_din_7 din[7] DVSS DVSS DVDD DVDD FE_PHN1_din_7
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC0_din_9 din[9] DVSS DVSS DVDD DVDD FE_PHN0_din_9
+ sky130_fd_sc_hs__clkbuf_2
XCTS_ccl_a_buf_00012 CTS_6 DVSS DVSS DVDD DVDD CTS_5 sky130_fd_sc_hs__clkbuf_4
XCTS_ccl_a_buf_00009 CTS_3 DVSS DVSS DVDD DVDD CTS_4 sky130_fd_sc_hs__clkbuf_1
XU14 CTS_6 DVSS DVSS DVDD DVDD CTS_3 sky130_fd_sc_hs__clkinv_4
XCTS_ccl_a_buf_00006 CTS_2 DVSS DVSS DVDD DVDD CTS_1 sky130_fd_sc_hs__clkbuf_4
XCTS_ccl_a_buf_00003 CTS_2 DVSS DVSS DVDD DVDD clk_prbs
+ sky130_fd_sc_hs__clkbuf_16
Xdiv0 clk rst CTS_6 CTS_5 DVDD DVSS div_b2_1
Xdiv1 CTS_3 rst CTS_2 DVDD DVSS div_b2_0
XiMUX_4__mux_4t1_hr_2t1_mux_1_dff_1_Q_reg CTS_1 FE_PHN9_din_15 DVSS DVSS DVDD
+ DVDD iMUX_4__mux_4t1_hr_2t1_mux_1_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_4__mux_4t1_hr_2t1_mux_0_dff_1_Q_reg CTS_1 FE_PHN15_din_13 DVSS DVSS DVDD
+ DVDD iMUX_4__mux_4t1_hr_2t1_mux_0_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_1_dff_1_Q_reg CTS_1 FE_PHN14_din_11 DVSS DVSS DVDD
+ DVDD iMUX_3__mux_4t1_hr_2t1_mux_1_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_0_dff_1_Q_reg CTS_1 FE_PHN0_din_9 DVSS DVSS DVDD
+ DVDD iMUX_3__mux_4t1_hr_2t1_mux_0_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_1_dff_1_Q_reg CTS_1 FE_PHN1_din_7 DVSS DVSS DVDD
+ DVDD iMUX_2__mux_4t1_hr_2t1_mux_1_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_0_dff_1_Q_reg CTS_1 FE_PHN8_din_5 DVSS DVSS DVDD
+ DVDD iMUX_2__mux_4t1_hr_2t1_mux_0_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_1_dff_1_Q_reg CTS_1 FE_PHN5_din_3 DVSS DVSS DVDD
+ DVDD iMUX_1__mux_4t1_hr_2t1_mux_1_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_0_dff_1_Q_reg CTS_1 FE_PHN6_din_1 DVSS DVSS DVDD
+ DVDD iMUX_1__mux_4t1_hr_2t1_mux_0_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_4__mux_4t1_hr_2t1_mux_2_dff_1_Q_reg CTS_5 iMUX_4__mux_4t1_hd[1] DVSS DVSS
+ DVDD DVDD iMUX_4__mux_4t1_hr_2t1_mux_2_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_2_dff_1_Q_reg CTS_5 iMUX_3__mux_4t1_hd[1] DVSS DVSS
+ DVDD DVDD iMUX_3__mux_4t1_hr_2t1_mux_2_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_2_dff_1_Q_reg CTS_5 iMUX_2__mux_4t1_hd[1] DVSS DVSS
+ DVDD DVDD iMUX_2__mux_4t1_hr_2t1_mux_2_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_2_dff_1_Q_reg CTS_5 iMUX_1__mux_4t1_hd[1] DVSS DVSS
+ DVDD DVDD iMUX_1__mux_4t1_hr_2t1_mux_2_D1M sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_0_dff_0_Q_reg CTS_1 FE_PHN10_din_0 DVSS DVSS DVDD
+ DVDD iMUX_1__mux_4t1_hr_2t1_mux_0_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_4__mux_4t1_hr_2t1_mux_1_dff_0_Q_reg CTS_1 FE_PHN11_din_14 DVSS DVSS DVDD
+ DVDD iMUX_4__mux_4t1_hr_2t1_mux_1_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_4__mux_4t1_hr_2t1_mux_0_dff_0_Q_reg CTS_1 FE_PHN7_din_12 DVSS DVSS DVDD
+ DVDD iMUX_4__mux_4t1_hr_2t1_mux_0_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_1_dff_0_Q_reg CTS_1 FE_PHN13_din_10 DVSS DVSS DVDD
+ DVDD iMUX_3__mux_4t1_hr_2t1_mux_1_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_0_dff_0_Q_reg CTS_1 FE_PHN2_din_8 DVSS DVSS DVDD
+ DVDD iMUX_3__mux_4t1_hr_2t1_mux_0_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_1_dff_0_Q_reg CTS_1 FE_PHN4_din_6 DVSS DVSS DVDD
+ DVDD iMUX_2__mux_4t1_hr_2t1_mux_1_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_0_dff_0_Q_reg CTS_1 FE_PHN12_din_4 DVSS DVSS DVDD
+ DVDD iMUX_2__mux_4t1_hr_2t1_mux_0_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_1_dff_0_Q_reg CTS_1 FE_PHN3_din_2 DVSS DVSS DVDD
+ DVDD iMUX_1__mux_4t1_hr_2t1_mux_1_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_4__mux_4t1_hr_2t1_mux_2_dff_0_Q_reg CTS_5 iMUX_4__mux_4t1_hd[0] DVSS DVSS
+ DVDD DVDD iMUX_4__mux_4t1_hr_2t1_mux_2_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_3__mux_4t1_hr_2t1_mux_2_dff_0_Q_reg CTS_5 iMUX_3__mux_4t1_hd[0] DVSS DVSS
+ DVDD DVDD iMUX_3__mux_4t1_hr_2t1_mux_2_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_2__mux_4t1_hr_2t1_mux_2_dff_0_Q_reg CTS_5 iMUX_2__mux_4t1_hd[0] DVSS DVSS
+ DVDD DVDD iMUX_2__mux_4t1_hr_2t1_mux_2_D0L sky130_fd_sc_hs__dfxtp_4
XiMUX_1__mux_4t1_hr_2t1_mux_2_dff_0_Q_reg CTS_5 iMUX_1__mux_4t1_hd[0] DVSS DVSS
+ DVDD DVDD iMUX_1__mux_4t1_hr_2t1_mux_2_D0L sky130_fd_sc_hs__dfxtp_4
XU15 iMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_N0 iMUX_1__mux_4t1_hr_2t1_mux_1_D1M
+ iMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_N2 iMUX_1__mux_4t1_hr_2t1_mux_1_D0L DVSS
+ DVSS DVDD DVDD iMUX_1__mux_4t1_hd[1] sky130_fd_sc_hs__a22o_1
XU16 CTS_5 iMUX_1__mux_4t1_hr_2t1_mux_2_D1M CTS_4
+ iMUX_1__mux_4t1_hr_2t1_mux_2_D0L DVSS DVSS DVDD DVDD dout[0]
+ sky130_fd_sc_hs__a22o_1
XU17 iMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_N0 iMUX_2__mux_4t1_hr_2t1_mux_0_D1M
+ iMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_N2 iMUX_2__mux_4t1_hr_2t1_mux_0_D0L DVSS
+ DVSS DVDD DVDD iMUX_2__mux_4t1_hd[0] sky130_fd_sc_hs__a22o_1
XU18 iMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_N0 iMUX_2__mux_4t1_hr_2t1_mux_1_D1M
+ iMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_N2 iMUX_2__mux_4t1_hr_2t1_mux_1_D0L DVSS
+ DVSS DVDD DVDD iMUX_2__mux_4t1_hd[1] sky130_fd_sc_hs__a22o_1
XU19 CTS_5 iMUX_2__mux_4t1_hr_2t1_mux_2_D1M CTS_4
+ iMUX_2__mux_4t1_hr_2t1_mux_2_D0L DVSS DVSS DVDD DVDD dout[1]
+ sky130_fd_sc_hs__a22o_1
XU20 iMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_N0 iMUX_3__mux_4t1_hr_2t1_mux_0_D1M
+ iMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_N2 iMUX_3__mux_4t1_hr_2t1_mux_0_D0L DVSS
+ DVSS DVDD DVDD iMUX_3__mux_4t1_hd[0] sky130_fd_sc_hs__a22o_1
XU21 iMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_N0 iMUX_3__mux_4t1_hr_2t1_mux_1_D1M
+ iMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_N2 iMUX_3__mux_4t1_hr_2t1_mux_1_D0L DVSS
+ DVSS DVDD DVDD iMUX_3__mux_4t1_hd[1] sky130_fd_sc_hs__a22o_1
XU22 CTS_5 iMUX_3__mux_4t1_hr_2t1_mux_2_D1M CTS_4
+ iMUX_3__mux_4t1_hr_2t1_mux_2_D0L DVSS DVSS DVDD DVDD dout[2]
+ sky130_fd_sc_hs__a22o_1
XU23 iMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_N0 iMUX_4__mux_4t1_hr_2t1_mux_0_D1M
+ iMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_N2 iMUX_4__mux_4t1_hr_2t1_mux_0_D0L DVSS
+ DVSS DVDD DVDD iMUX_4__mux_4t1_hd[0] sky130_fd_sc_hs__a22o_1
XU24 iMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_N0 iMUX_4__mux_4t1_hr_2t1_mux_1_D1M
+ iMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_N2 iMUX_4__mux_4t1_hr_2t1_mux_1_D0L DVSS
+ DVSS DVDD DVDD iMUX_4__mux_4t1_hd[1] sky130_fd_sc_hs__a22o_1
XU25 CTS_5 iMUX_4__mux_4t1_hr_2t1_mux_2_D1M CTS_4
+ iMUX_4__mux_4t1_hr_2t1_mux_2_D0L DVSS DVSS DVDD DVDD dout[3]
+ sky130_fd_sc_hs__a22o_1
XU26 iMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_N0 iMUX_1__mux_4t1_hr_2t1_mux_0_D1M
+ iMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_N2 iMUX_1__mux_4t1_hr_2t1_mux_0_D0L DVSS
+ DVSS DVDD DVDD iMUX_1__mux_4t1_hd[0] sky130_fd_sc_hs__a22o_1
XiMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_B_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_N0 sky130_fd_sc_hs__buf_2
XiMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_1__mux_4t1_hr_2t1_mux_0_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_2__mux_4t1_hr_2t1_mux_0_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_2__mux_4t1_hr_2t1_mux_1_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_3__mux_4t1_hr_2t1_mux_0_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_1__mux_4t1_hr_2t1_mux_1_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_3__mux_4t1_hr_2t1_mux_1_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_4__mux_4t1_hr_2t1_mux_0_mux_0_N2 sky130_fd_sc_hs__inv_4
XiMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_I_0 clk_prbs DVSS DVSS DVDD DVDD
+ iMUX_4__mux_4t1_hr_2t1_mux_1_mux_0_N2 sky130_fd_sc_hs__inv_4
.ENDS

.SUBCKT qr_mux_fixed DIN0 DIN1 DIN2 DIN3 E0 E1 DOUT DVDD DVSS
Xmux DIN0 DIN1 DIN2 DIN3 E0 E1 DVSS DVSS DVDD DVDD DOUT sky130_fd_sc_hs__mux4_4
.ENDS

.SUBCKT qr_4t1_mux_top clk_Q clk_QB clk_I clk_IB din[3] din[2] din[1] din[0]
+ rst din_2_dummy din_3_dummy D1DQB_dummy D1DIB_dummy data mux_out_dummy DVSS
+ DVDD
XFE_PHC0_din_3 din[3] DVSS DVSS DVDD DVDD FE_PHN0_din_3
+ sky130_fd_sc_hs__clkbuf_2
XCTS_ccl_a_buf_00003 clk_IB DVSS DVSS DVDD DVDD CTS_2 sky130_fd_sc_hs__clkbuf_1
XCTS_ccl_a_buf_00006 clk_QB DVSS DVSS DVDD DVDD CTS_1 sky130_fd_sc_hs__clkbuf_2
XCTS_ccl_a_buf_00009 clk_I DVSS DVSS DVDD DVDD CTS_5 sky130_fd_sc_hs__clkbuf_1
XCTS_ccl_a_buf_00012 clk_Q DVSS DVSS DVDD DVDD CTS_4 sky130_fd_sc_hs__clkbuf_1
XU1 mux_out DVSS DVSS DVDD DVDD data sky130_fd_sc_hs__clkinv_4
Xdff_Q0 CTS_4 FE_PHN0_din_3 DVSS DVSS DVDD DVDD D0DQ sky130_fd_sc_hs__dfxtp_4
Xdff_Q0_dummy CTS_1 din_3_dummy DVSS DVSS DVDD DVDD D0DQ_dummy
+ sky130_fd_sc_hs__dfxtp_2
Xdff_I0 CTS_5 din[2] DVSS DVSS DVDD DVDD D0DI sky130_fd_sc_hs__dfxtp_4
Xdff_I0_dummy CTS_2 din_2_dummy DVSS DVSS DVDD DVDD D0DI_dummy
+ sky130_fd_sc_hs__dfxtp_2
Xdff_QB0 CTS_4 din[1] DVSS DVSS DVDD DVDD D0DQB sky130_fd_sc_hs__dfxtp_2
Xdff_QB1 CTS_1 D0DQB DVSS DVSS DVDD DVDD D1DQB sky130_fd_sc_hs__dfxtp_2
Xdff_IB0 CTS_5 din[0] DVSS DVSS DVDD DVDD D0DIB sky130_fd_sc_hs__dfxtp_2
Xdff_IB1 CTS_2 D0DIB DVSS DVSS DVDD DVDD D1DIB sky130_fd_sc_hs__dfxtp_2
Xmux_4_dummy D0DI_dummy D1DQB_dummy D0DQ_dummy D1DIB_dummy clk_QB clk_IB
+ mux_out_dummy DVDD DVSS qr_mux_fixed
Xmux_4_mux D0DI D1DQB D0DQ D1DIB clk_Q clk_I DVSS DVSS DVDD DVDD mux_out
+ sky130_fd_sc_hs__mux4_1
.ENDS

.SUBCKT delay_cell_osc in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_1 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_2 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_3 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_4 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_5 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT delay_cell_osc_SPC_6 in en out DVDD DVSS
Xinand in en DVSS DVSS DVDD DVDD out sky130_fd_sc_hs__nand2_4
.ENDS

.SUBCKT aux_core glob_en osc_000 osc_030 osc_060 osc_090 osc_120 osc_150
+ osc_180 DVDD DVSS
Xdel1 osc_000 glob_en osc_030 DVDD DVSS delay_cell_osc
Xdel2 osc_030 glob_en osc_060 DVDD DVSS delay_cell_osc_SPC_1
Xdel3 osc_060 glob_en osc_90 DVDD DVSS delay_cell_osc_SPC_2
Xdel4 osc_90 glob_en osc_120 DVDD DVSS delay_cell_osc_SPC_3
Xdel5 osc_120 glob_en osc_150 DVDD DVSS delay_cell_osc_SPC_4
Xdel6 osc_150 glob_en osc_180 DVDD DVSS delay_cell_osc_SPC_5
Xdel7 osc_180 glob_en osc_000 DVDD DVSS delay_cell_osc_SPC_6
.ENDS

.SUBCKT SNPS_CLOCK_GATE_HIGH_fine_freq_track_0 CLK EN ENCLK TE DVDD DVSS
XLTIE DVSS DVSS DVDD DVDD 1000 LTIE_LONET sky130_fd_sc_hs__conb_1
Xlatch CLK EN LTIE_LONET DVSS DVSS DVDD DVDD ENCLK sky130_fd_sc_hs__sdlclkp_1
.ENDS

.SUBCKT SNPS_CLOCK_GATE_HIGH_fine_freq_track_1 CLK EN ENCLK TE DVDD DVSS
XLTIE DVSS DVSS DVDD DVDD 1000 LTIE_LONET sky130_fd_sc_hs__conb_1
Xlatch CLK EN LTIE_LONET DVSS DVSS DVDD DVDD ENCLK sky130_fd_sc_hs__sdlclkp_4
.ENDS

.SUBCKT fine_freq_track clk_out div_ratio_half[5] div_ratio_half[4]
+ div_ratio_half[3] div_ratio_half[2] div_ratio_half[1] div_ratio_half[0]
+ ref_clk rst aux_osc_en fftl_en fine_control_avg_window_select[4]
+ fine_control_avg_window_select[3] fine_control_avg_window_select[2]
+ fine_control_avg_window_select[1] fine_control_avg_window_select[0]
+ fine_con_step_size[3] fine_con_step_size[2] fine_con_step_size[1]
+ fine_con_step_size[0] manual_control_osc[12] manual_control_osc[11]
+ manual_control_osc[10] manual_control_osc[9] manual_control_osc[8]
+ manual_control_osc[7] manual_control_osc[6] manual_control_osc[5]
+ manual_control_osc[4] manual_control_osc[3] manual_control_osc[2]
+ manual_control_osc[1] manual_control_osc[0] aux_clk_out out_star
+ osc_fine_con_final[12] osc_fine_con_final[11] osc_fine_con_final[10]
+ osc_fine_con_final[9] osc_fine_con_final[8] osc_fine_con_final[7]
+ osc_fine_con_final[6] osc_fine_con_final[5] osc_fine_con_final[4]
+ osc_fine_con_final[3] osc_fine_con_final[2] osc_fine_con_final[1]
+ osc_fine_con_final[0] DVSS DVDD
XFE_RC_33_0 rst sync_flag DVSS DVSS DVDD DVDD FE_RN_14_0
+ sky130_fd_sc_hs__nor2_1
XFE_RC_32_0 n7 FE_RN_14_0 DVSS DVSS DVDD DVDD net841 sky130_fd_sc_hs__nand2b_1
XFE_RC_31_0 osc_clk_count[5] n199 DVSS DVSS DVDD DVDD FE_RN_12_0
+ sky130_fd_sc_hs__xnor2_1
XFE_RC_30_0 rst FE_OCPN3_n191 sync_flag DVSS DVSS DVDD DVDD FE_RN_13_0
+ sky130_fd_sc_hs__nand3b_2
XFE_RC_29_0 FE_RN_12_0 FE_RN_13_0 DVSS DVSS DVDD DVDD n8
+ sky130_fd_sc_hs__nor2_1
XFE_RC_28_0 rst n200 FE_RN_2_0 DVSS DVSS DVDD DVDD FE_RN_11_0
+ sky130_fd_sc_hs__or3b_2
XFE_RC_27_0 FE_RN_11_0 n7 DVSS DVSS DVDD DVDD n12 sky130_fd_sc_hs__nor2_1
XFE_RC_26_0 div_ratio_half[4] osc_clk_count[4] DVSS DVSS DVDD DVDD FE_RN_10_0
+ sky130_fd_sc_hs__nand2b_4
XFE_RC_25_0 FE_RN_10_0 n145 DVSS DVSS DVDD DVDD n149 sky130_fd_sc_hs__xnor2_1
XFE_OCPC7_osc_clk_count_1 osc_clk_count[1] DVSS DVSS DVDD DVDD n127
+ sky130_fd_sc_hs__inv_2
XFE_RC_24_0 FE_RN_5_0 rst DVSS DVSS DVDD DVDD FE_RN_9_0 sky130_fd_sc_hs__nor2_2
XFE_RC_23_0 FE_OCPN3_n191 FE_RN_9_0 DVSS DVSS DVDD DVDD n10
+ sky130_fd_sc_hs__and2_2
XFE_RC_22_0 n198 rst n200 DVSS DVSS DVDD DVDD FE_RN_7_0 sky130_fd_sc_hs__nor3_1
XFE_RC_21_0 n199 FE_RN_7_0 DVSS DVSS DVDD DVDD FE_RN_8_0
+ sky130_fd_sc_hs__nand2b_1
XFE_RC_20_0 FE_RN_8_0 n7 DVSS DVSS DVDD DVDD n9 sky130_fd_sc_hs__nor2_1
XFE_RC_19_0 n192 sync_flag DVSS DVSS DVDD DVDD FE_RN_5_0
+ sky130_fd_sc_hs__nand2b_1
XFE_RC_16_0 div_ratio_half[3] n441 FE_RN_1 DVSS DVSS DVDD DVDD n139
+ sky130_fd_sc_hs__o21ai_1
XFE_RC_13_0 n7 n155 DVSS DVSS DVDD DVDD n455 sky130_fd_sc_hs__nor2b_1
XFE_RC_12_0 rst n157 DVSS DVSS DVDD DVDD FE_RN_4_0 sky130_fd_sc_hs__nand2b_1
XFE_RC_11_0 FE_RN_4_0 FE_OCPN3_n191 DVSS DVSS DVDD DVDD n13
+ sky130_fd_sc_hs__nor2b_1
XU153_dup n441 div_ratio_half[3] DVSS DVSS DVDD DVDD FE_RN_1
+ sky130_fd_sc_hs__nand2_2
XFE_RC_7_0 n189 n190 DVSS DVSS DVDD DVDD FE_RN_2_0 sky130_fd_sc_hs__nand2_1
XFE_OCPC5_n191 n7 DVSS DVSS DVDD DVDD FE_OCPN3_n191 sky130_fd_sc_hs__inv_4
XFE_OCPC3_n191 n191 DVSS DVSS DVDD DVDD n7 sky130_fd_sc_hs__inv_4
XFE_RC_2_0 osc_clk_count[4] div_ratio_half[4] DVSS DVSS DVDD DVDD FE_RN_0_0
+ sky130_fd_sc_hs__nand2_4
XFE_RC_1_0 div_ratio_half[4] osc_clk_count[4] FE_RN_0_0 DVSS DVSS DVDD DVDD
+ n124 sky130_fd_sc_hs__o21ai_2
XFE_RC_0_0 n150 n151 n149 n148 DVSS DVSS DVDD DVDD n191
+ sky130_fd_sc_hs__nand4_2
XFE_OFC2_n135 n135 DVSS DVSS DVDD DVDD n136 sky130_fd_sc_hs__inv_2
XFE_OFC1_n184 n184 DVSS DVSS DVDD DVDD FE_OFN1_n184 sky130_fd_sc_hs__clkbuf_8
XFE_OFC0_ref_clk ref_clk DVSS DVSS DVDD DVDD FE_OFN0_ref_clk
+ sky130_fd_sc_hs__clkbuf_2
Xaux_osc aux_osc_en aux_clk_out 1000 1001 1002 1003 1004 1005 DVDD DVSS
+ aux_core
Xclk_gate_osc_clk_count_reg_5_ clk_out net841 net845 1006 DVDD DVSS
+ SNPS_CLOCK_GATE_HIGH_fine_freq_track_0
Xclk_gate_osc_fine_con_reg_12_ commit_clk N312 net856 1007 DVDD DVSS
+ SNPS_CLOCK_GATE_HIGH_fine_freq_track_1
Xstat_error_reg_24_ ref_clk N229 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[24] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_23_ ref_clk N228 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[23] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_22_ ref_clk N227 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[22] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_21_ ref_clk N226 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[21] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_20_ ref_clk N225 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[20] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_19_ ref_clk N224 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[19] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_18_ FE_OFN0_ref_clk N223 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[18] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_17_ FE_OFN0_ref_clk N222 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[17] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_16_ FE_OFN0_ref_clk N221 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[16] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_15_ FE_OFN0_ref_clk N220 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[15] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_14_ FE_OFN0_ref_clk N219 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[14] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_13_ FE_OFN0_ref_clk N218 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[13] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_12_ FE_OFN0_ref_clk N217 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[12] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_11_ FE_OFN0_ref_clk N216 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[11] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_10_ FE_OFN0_ref_clk N215 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[10] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_9_ FE_OFN0_ref_clk N214 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[9] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_8_ FE_OFN0_ref_clk N213 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[8] sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_7_ ref_clk N212 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[7]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_6_ ref_clk N211 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[6]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_5_ ref_clk N210 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[5]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_4_ ref_clk N209 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[4]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_3_ ref_clk N208 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[3]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_2_ ref_clk N207 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[2]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_1_ ref_clk N206 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_error[1]
+ sky130_fd_sc_hs__dfrtn_1
Xstat_error_reg_0_ FE_OFN0_ref_clk N205 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_error[0] sky130_fd_sc_hs__dfrtn_1
Xstat_clean_reg_24_ ref_clk N254 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[24] 1008 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_23_ ref_clk N253 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[23] 1009 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_22_ ref_clk N252 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[22] 1010 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_21_ ref_clk N251 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[21] 1011 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_20_ ref_clk N250 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[20] 1012 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_19_ FE_OFN0_ref_clk N249 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[19] 1013 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_18_ FE_OFN0_ref_clk N248 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[18] 1014 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_17_ FE_OFN0_ref_clk N247 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[17] 1015 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_16_ FE_OFN0_ref_clk N246 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[16] 1016 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_15_ FE_OFN0_ref_clk N245 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[15] 1017 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_14_ FE_OFN0_ref_clk N244 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[14] 1018 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_13_ FE_OFN0_ref_clk N243 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[13] 1019 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_12_ FE_OFN0_ref_clk N242 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[12] 1020 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_10_ FE_OFN0_ref_clk N240 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[10] 1021 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_9_ FE_OFN0_ref_clk N239 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[9] 1022 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_8_ FE_OFN0_ref_clk N238 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[8] 1023 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_7_ ref_clk N237 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[7]
+ 1024 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_6_ ref_clk N236 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[6]
+ 1025 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_5_ ref_clk N235 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[5]
+ 1026 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_4_ ref_clk N234 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[4]
+ 1027 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_3_ ref_clk N233 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[3]
+ 1028 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_2_ ref_clk N232 FE_OFN1_n184 DVSS DVSS DVDD DVDD stat_clean[2]
+ 1029 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_1_ FE_OFN0_ref_clk N231 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[1] 1030 sky130_fd_sc_hs__dfrbp_1
Xstat_clean_reg_0_ FE_OFN0_ref_clk N230 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[0] 1031 sky130_fd_sc_hs__dfrbp_1
XU5 rst esample_N2 DVSS DVSS DVDD DVDD n3 sky130_fd_sc_hs__nor2b_1
XU6 rst esample_N2 DVSS DVSS DVDD DVDD n4 sky130_fd_sc_hs__nor2b_1
XU8 rst n7 DVSS DVSS DVDD DVDD n6 sky130_fd_sc_hs__nor2b_1
XU12 rst n455 DVSS DVSS DVDD DVDD n11 sky130_fd_sc_hs__nor2b_2
XDP_OP_68J1_123_8173_U14 osc_fine_con[0] DP_OP_68J1_123_8173_n35
+ DP_OP_68J1_123_8173_n21 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n13
+ C21_DATA2_0 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U13 DP_OP_68J1_123_8173_n20 osc_fine_con[1]
+ DP_OP_68J1_123_8173_n13 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n12
+ C21_DATA2_1 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U12 DP_OP_68J1_123_8173_n19 osc_fine_con[2]
+ DP_OP_68J1_123_8173_n12 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n11
+ C21_DATA2_2 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U11 DP_OP_68J1_123_8173_n18 osc_fine_con[3]
+ DP_OP_68J1_123_8173_n11 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n10
+ C21_DATA2_3 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U10 DP_OP_68J1_123_8173_n35 osc_fine_con[4]
+ DP_OP_68J1_123_8173_n10 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n9
+ C21_DATA2_4 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U9 DP_OP_68J1_123_8173_n35 osc_fine_con[5]
+ DP_OP_68J1_123_8173_n9 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n8 C21_DATA2_5
+ sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U8 DP_OP_68J1_123_8173_n35 osc_fine_con[6]
+ DP_OP_68J1_123_8173_n8 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n7 C21_DATA2_6
+ sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U7 DP_OP_68J1_123_8173_n35 osc_fine_con[7]
+ DP_OP_68J1_123_8173_n7 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n6 C21_DATA2_7
+ sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U6 DP_OP_68J1_123_8173_n35 osc_fine_con[8]
+ DP_OP_68J1_123_8173_n6 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n5 C21_DATA2_8
+ sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U5 DP_OP_68J1_123_8173_n35 osc_fine_con[9]
+ DP_OP_68J1_123_8173_n5 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n4 C21_DATA2_9
+ sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U4 DP_OP_68J1_123_8173_n35 osc_fine_con[10]
+ DP_OP_68J1_123_8173_n4 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n3
+ C21_DATA2_10 sky130_fd_sc_hs__fa_2
XDP_OP_68J1_123_8173_U3 DP_OP_68J1_123_8173_n35 osc_fine_con[11]
+ DP_OP_68J1_123_8173_n3 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n2
+ C21_DATA2_11 sky130_fd_sc_hs__fa_2
Xesample_DF_reg esample_osc_out_star_b n3 DVSS DVSS DVDD DVDD esample_DF
+ sky130_fd_sc_hs__dfxtp_4
Xesample_DR_reg out_star n4 DVSS DVSS DVDD DVDD esample_DR
+ sky130_fd_sc_hs__dfxtp_4
Xout_star_reg clk_out n6 DVSS DVSS DVDD DVDD out_star sky130_fd_sc_hs__dfxtp_4
Xsync_flag_reg ref_clk n448 DVSS DVSS DVDD DVDD sync_flag
+ sky130_fd_sc_hs__dfxtp_4
Xosc_clk_count_reg_5_ net845 n8 DVSS DVSS DVDD DVDD osc_clk_count[5]
+ sky130_fd_sc_hs__dfxtp_2
Xosc_clk_count_reg_2_ net845 n11 DVSS DVSS DVDD DVDD osc_clk_count[2]
+ sky130_fd_sc_hs__dfxtp_2
XU147 n124 DVSS DVSS DVDD DVDD n147 sky130_fd_sc_hs__inv_2
XU148 n147 osc_clk_count[3] DVSS DVSS DVDD DVDD n126 sky130_fd_sc_hs__nand2_2
XU149 div_ratio_half[0] div_ratio_half[1] DVSS DVSS DVDD DVDD n135
+ sky130_fd_sc_hs__nor2_4
XU150 div_ratio_half[2] DVSS DVSS DVDD DVDD n130 sky130_fd_sc_hs__inv_4
XU151 n135 n130 DVSS DVSS DVDD DVDD n138 sky130_fd_sc_hs__nand2_2
XU152 n124 n138 DVSS DVSS DVDD DVDD n125 sky130_fd_sc_hs__nand2_1
XU153 n441 div_ratio_half[3] DVSS DVSS DVDD DVDD n137 sky130_fd_sc_hs__nand2_2
XU154 n126 n125 n137 DVSS DVSS DVDD DVDD n151 sky130_fd_sc_hs__nand3_1
XU156 n127 osc_clk_count[0] DVSS DVSS DVDD DVDD n190 sky130_fd_sc_hs__nand2_1
XU157 div_ratio_half[1] DVSS DVSS DVDD DVDD n128 sky130_fd_sc_hs__inv_4
XU158 osc_clk_count[1] div_ratio_half[0] n128 DVSS DVSS DVDD DVDD n129
+ sky130_fd_sc_hs__a21oi_1
XU159 n190 n129 DVSS DVSS DVDD DVDD n133 sky130_fd_sc_hs__nand2_1
XU160 n135 n130 n138 DVSS DVSS DVDD DVDD n131 sky130_fd_sc_hs__o21ai_1
XU161 n131 osc_clk_count[2] DVSS DVSS DVDD DVDD n132 sky130_fd_sc_hs__xnor2_1
XU162 n133 n132 DVSS DVSS DVDD DVDD n143 sky130_fd_sc_hs__nand2_1
XU163 osc_clk_count[0] DVSS DVSS DVDD DVDD n134 sky130_fd_sc_hs__inv_2
XU164 n134 osc_clk_count[1] DVSS DVSS DVDD DVDD n189 sky130_fd_sc_hs__nand2_1
XU166 n136 osc_clk_count[1] osc_clk_count[0] div_ratio_half[0] DVSS DVSS DVDD
+ DVDD n141 sky130_fd_sc_hs__a2bb2oi_1
XU168 n139 n138 DVSS DVSS DVDD DVDD n140 sky130_fd_sc_hs__nand2_2
XU169 div_ratio_half[1] n189 n141 n140 DVSS DVSS DVDD DVDD n142
+ sky130_fd_sc_hs__o211ai_1
XU173 div_ratio_half[5] osc_clk_count[5] DVSS DVSS DVDD DVDD n145
+ sky130_fd_sc_hs__xnor2_1
XU175 n147 div_ratio_half[3] DVSS DVSS DVDD DVDD n148 sky130_fd_sc_hs__nand2_1
XU179 n970 DVSS DVSS DVDD DVDD n152 sky130_fd_sc_hs__inv_4
XU180 CurrentState_1_ n152 DVSS DVSS DVDD DVDD DP_OP_68J1_123_8173_n35
+ sky130_fd_sc_hs__nor2_4
XU181 commit_clk_cnt[0] DVSS DVSS DVDD DVDD N74 sky130_fd_sc_hs__inv_4
XU182 out_star DVSS DVSS DVDD DVDD esample_osc_out_star_b
+ sky130_fd_sc_hs__inv_4
XU183 osc_clk_count[0] osc_clk_count[1] DVSS DVSS DVDD DVDD n153
+ sky130_fd_sc_hs__and2_2
XU184 osc_clk_count[2] n153 sync_flag DVSS DVSS DVDD DVDD n154
+ sky130_fd_sc_hs__o21ai_1
XU185 n153 osc_clk_count[2] DVSS DVSS DVDD DVDD n193 sky130_fd_sc_hs__nand2_2
XU186 n193 DVSS DVSS DVDD DVDD n197 sky130_fd_sc_hs__inv_4
XU187 n154 n197 DVSS DVSS DVDD DVDD n155 sky130_fd_sc_hs__nor2_1
XU190 sync_flag DVSS DVSS DVDD DVDD n200 sky130_fd_sc_hs__inv_4
XU191 n200 osc_clk_count[0] DVSS DVSS DVDD DVDD n157 sky130_fd_sc_hs__nor2_1
XU194 fine_control_avg_window_select[0] DVSS DVSS DVDD DVDD n426
+ sky130_fd_sc_hs__inv_4
XU195 fine_control_avg_window_select[3] fine_control_avg_window_select[4] DVSS
+ DVSS DVDD DVDD n423 sky130_fd_sc_hs__nor2_1
XU196 fine_control_avg_window_select[3] fine_control_avg_window_select[4] DVSS
+ DVSS DVDD DVDD n421 sky130_fd_sc_hs__and2_2
XU197 fine_control_avg_window_select[4] fine_control_avg_window_select[3] DVSS
+ DVSS DVDD DVDD n419 sky130_fd_sc_hs__nor2b_1
XU198 fine_control_avg_window_select[3] fine_control_avg_window_select[4] DVSS
+ DVSS DVDD DVDD n420 sky130_fd_sc_hs__nor2b_1
XU199 commit_clk_cnt[25] n421 commit_clk_cnt[9] n419 commit_clk_cnt[17] n420
+ DVSS DVSS DVDD DVDD n422 sky130_fd_sc_hs__a222o_1
XU200 commit_clk_cnt[25] n423 n422 DVSS DVSS DVDD DVDD n166
+ sky130_fd_sc_hs__a21oi_1
XU201 commit_clk_cnt[19] n420 commit_clk_cnt[11] n419 DVSS DVSS DVDD DVDD n160
+ sky130_fd_sc_hs__a22oi_1
XU202 commit_clk_cnt[27] n421 commit_clk_cnt[3] n423 DVSS DVSS DVDD DVDD n159
+ sky130_fd_sc_hs__a22oi_1
XU203 n160 n159 fine_control_avg_window_select[2] DVSS DVSS DVDD DVDD n165
+ sky130_fd_sc_hs__a21oi_1
XU204 commit_clk_cnt[21] n420 commit_clk_cnt[13] n419 DVSS DVSS DVDD DVDD n163
+ sky130_fd_sc_hs__a22oi_1
XU205 commit_clk_cnt[29] n421 commit_clk_cnt[5] n423 DVSS DVSS DVDD DVDD n162
+ sky130_fd_sc_hs__a22oi_1
XU206 fine_control_avg_window_select[1] DVSS DVSS DVDD DVDD n414
+ sky130_fd_sc_hs__inv_4
XU207 fine_control_avg_window_select[2] n414 DVSS DVSS DVDD DVDD n161
+ sky130_fd_sc_hs__nand2_1
XU208 n163 n162 n161 DVSS DVSS DVDD DVDD n164 sky130_fd_sc_hs__a21oi_1
XU209 fine_control_avg_window_select[1] n165 n164 DVSS DVSS DVDD DVDD n417
+ sky130_fd_sc_hs__a21oi_1
XU210 fine_control_avg_window_select[1] fine_control_avg_window_select[2] n166
+ n417 DVSS DVSS DVDD DVDD n182 sky130_fd_sc_hs__o31ai_1
XU211 commit_clk_cnt[24] n420 commit_clk_cnt[16] n419 commit_clk_cnt[8] n423
+ DVSS DVSS DVDD DVDD n167 sky130_fd_sc_hs__a222oi_1
XU212 commit_clk_cnt[23] n420 commit_clk_cnt[15] n419 commit_clk_cnt[7] n423
+ DVSS DVSS DVDD DVDD n418 sky130_fd_sc_hs__a222oi_1
XU213 fine_control_avg_window_select[0] n167 n418 n426 DVSS DVSS DVDD DVDD n168
+ sky130_fd_sc_hs__a22oi_1
XU214 commit_clk_cnt[31] n421 n168 DVSS DVSS DVDD DVDD n180
+ sky130_fd_sc_hs__a21oi_1
XU215 fine_control_avg_window_select[1] fine_control_avg_window_select[2] DVSS
+ DVSS DVDD DVDD n415 sky130_fd_sc_hs__nand2_1
XU216 fine_control_avg_window_select[2] DVSS DVSS DVDD DVDD n178
+ sky130_fd_sc_hs__inv_4
XU217 commit_clk_cnt[20] n420 commit_clk_cnt[12] n419 DVSS DVSS DVDD DVDD n170
+ sky130_fd_sc_hs__a22oi_1
XU218 commit_clk_cnt[28] n421 commit_clk_cnt[4] n423 DVSS DVSS DVDD DVDD n169
+ sky130_fd_sc_hs__a22oi_1
XU219 n170 n169 DVSS DVSS DVDD DVDD n413 sky130_fd_sc_hs__nand2_2
XU220 commit_clk_cnt[14] n419 commit_clk_cnt[6] n423 DVSS DVSS DVDD DVDD n177
+ sky130_fd_sc_hs__a22oi_1
XU221 commit_clk_cnt[30] n421 DVSS DVSS DVDD DVDD n416 sky130_fd_sc_hs__nand2_1
XU222 n416 DVSS DVSS DVDD DVDD n171 sky130_fd_sc_hs__inv_4
XU223 commit_clk_cnt[22] n420 n171 n178 DVSS DVSS DVDD DVDD n176
+ sky130_fd_sc_hs__a211oi_1
XU224 commit_clk_cnt[18] n420 commit_clk_cnt[10] n419 DVSS DVSS DVDD DVDD n173
+ sky130_fd_sc_hs__a22oi_1
XU225 commit_clk_cnt[26] n421 fine_control_avg_window_select[2] DVSS DVSS DVDD
+ DVDD n172 sky130_fd_sc_hs__a21oi_1
XU226 n173 n172 DVSS DVSS DVDD DVDD n174 sky130_fd_sc_hs__nand2_2
XU227 commit_clk_cnt[2] n423 n174 DVSS DVSS DVDD DVDD n175
+ sky130_fd_sc_hs__a21oi_1
XU228 n177 n176 n175 DVSS DVSS DVDD DVDD n412 sky130_fd_sc_hs__a21oi_1
XU229 n178 fine_control_avg_window_select[1] n413 n412 n414 DVSS DVSS DVDD DVDD
+ n179 sky130_fd_sc_hs__a32oi_1
XU230 n180 n415 n179 n426 DVSS DVSS DVDD DVDD n181 sky130_fd_sc_hs__o22ai_1
XU242 CurrentState_1_ C21_DATA2_0 DVSS DVSS DVDD DVDD N299
+ sky130_fd_sc_hs__nor2b_1
XU243 CurrentState_1_ C21_DATA2_4 DVSS DVSS DVDD DVDD N303
+ sky130_fd_sc_hs__nor2b_1
XU244 CurrentState_1_ C21_DATA2_5 DVSS DVSS DVDD DVDD N304
+ sky130_fd_sc_hs__nor2b_1
XU245 CurrentState_1_ C21_DATA2_6 DVSS DVSS DVDD DVDD N305
+ sky130_fd_sc_hs__nor2b_1
XU246 CurrentState_1_ C21_DATA2_1 DVSS DVSS DVDD DVDD N300
+ sky130_fd_sc_hs__nor2b_1
XU247 CurrentState_1_ C21_DATA2_8 DVSS DVSS DVDD DVDD N307
+ sky130_fd_sc_hs__nor2b_1
XU248 CurrentState_1_ C21_DATA2_3 DVSS DVSS DVDD DVDD N302
+ sky130_fd_sc_hs__nor2b_1
XU249 CurrentState_1_ C21_DATA2_2 DVSS DVSS DVDD DVDD N301
+ sky130_fd_sc_hs__nor2b_1
XU250 CurrentState_1_ C21_DATA2_9 DVSS DVSS DVDD DVDD N308
+ sky130_fd_sc_hs__nor2b_1
XU251 CurrentState_1_ C21_DATA2_7 DVSS DVSS DVDD DVDD N306
+ sky130_fd_sc_hs__nor2b_1
XU252 CurrentState_1_ C21_DATA2_10 DVSS DVSS DVDD DVDD N309
+ sky130_fd_sc_hs__nor2b_1
XU253 CurrentState_1_ C21_DATA2_11 DVSS DVSS DVDD DVDD N310
+ sky130_fd_sc_hs__nor2b_1
XU254 osc_fine_con[12] DP_OP_68J1_123_8173_n35 DVSS DVSS DVDD DVDD n187
+ sky130_fd_sc_hs__xor2_1
XU255 n187 DP_OP_68J1_123_8173_n2 DVSS DVSS DVDD DVDD n188
+ sky130_fd_sc_hs__xor2_1
XU256 CurrentState_1_ n188 DVSS DVSS DVDD DVDD n446 sky130_fd_sc_hs__or2_1
XU258 n441 n193 DVSS DVSS DVDD DVDD n192 sky130_fd_sc_hs__xnor2_1
XU261 osc_clk_count[4] DVSS DVSS DVDD DVDD n194 sky130_fd_sc_hs__inv_4
XU262 n441 n194 n193 DVSS DVSS DVDD DVDD n199 sky130_fd_sc_hs__nor3_1
XU265 n197 osc_clk_count[3] osc_clk_count[4] DVSS DVSS DVDD DVDD n198
+ sky130_fd_sc_hs__a21oi_1
XU268 fine_con_step_size[3] DP_OP_68J1_123_8173_n35 DVSS DVSS DVDD DVDD
+ DP_OP_68J1_123_8173_n18 sky130_fd_sc_hs__xor2_1
XU269 fine_con_step_size[2] DP_OP_68J1_123_8173_n35 DVSS DVSS DVDD DVDD
+ DP_OP_68J1_123_8173_n19 sky130_fd_sc_hs__xor2_1
XU270 fine_con_step_size[1] DP_OP_68J1_123_8173_n35 DVSS DVSS DVDD DVDD
+ DP_OP_68J1_123_8173_n20 sky130_fd_sc_hs__xor2_1
XU271 fine_con_step_size[0] DP_OP_68J1_123_8173_n35 DVSS DVSS DVDD DVDD
+ DP_OP_68J1_123_8173_n21 sky130_fd_sc_hs__xor2_1
XU274 commit_clk_cnt[29] DVSS DVSS DVDD DVDD n202 sky130_fd_sc_hs__inv_4
XU275 commit_clk_cnt[27] DVSS DVSS DVDD DVDD n2050 sky130_fd_sc_hs__inv_4
XU276 commit_clk_cnt[25] DVSS DVSS DVDD DVDD n2080 sky130_fd_sc_hs__inv_4
XU277 commit_clk_cnt[23] DVSS DVSS DVDD DVDD n2110 sky130_fd_sc_hs__inv_4
XU278 commit_clk_cnt[21] DVSS DVSS DVDD DVDD n2140 sky130_fd_sc_hs__inv_4
XU279 commit_clk_cnt[19] DVSS DVSS DVDD DVDD n2170 sky130_fd_sc_hs__inv_4
XU280 commit_clk_cnt[17] DVSS DVSS DVDD DVDD n2200 sky130_fd_sc_hs__inv_4
XU281 commit_clk_cnt[15] DVSS DVSS DVDD DVDD n2230 sky130_fd_sc_hs__inv_4
XU282 commit_clk_cnt[13] DVSS DVSS DVDD DVDD n2260 sky130_fd_sc_hs__inv_4
XU283 commit_clk_cnt[11] DVSS DVSS DVDD DVDD n2290 sky130_fd_sc_hs__inv_4
XU284 commit_clk_cnt[9] DVSS DVSS DVDD DVDD n2320 sky130_fd_sc_hs__inv_4
XU285 commit_clk_cnt[7] DVSS DVSS DVDD DVDD n2350 sky130_fd_sc_hs__inv_4
XU286 commit_clk_cnt[5] DVSS DVSS DVDD DVDD n2380 sky130_fd_sc_hs__inv_4
XU287 commit_clk_cnt[3] DVSS DVSS DVDD DVDD n2410 sky130_fd_sc_hs__inv_4
XU288 commit_clk_cnt[1] DVSS DVSS DVDD DVDD n2440 sky130_fd_sc_hs__inv_4
XU289 n2440 N74 DVSS DVSS DVDD DVDD n2430 sky130_fd_sc_hs__nor2_1
XU290 commit_clk_cnt[2] n2430 DVSS DVSS DVDD DVDD n2420
+ sky130_fd_sc_hs__nand2_1
XU291 n2410 n2420 DVSS DVSS DVDD DVDD n2400 sky130_fd_sc_hs__nor2_1
XU292 commit_clk_cnt[4] n2400 DVSS DVSS DVDD DVDD n2390
+ sky130_fd_sc_hs__nand2_1
XU293 n2380 n2390 DVSS DVSS DVDD DVDD n2370 sky130_fd_sc_hs__nor2_1
XU294 commit_clk_cnt[6] n2370 DVSS DVSS DVDD DVDD n2360
+ sky130_fd_sc_hs__nand2_1
XU295 n2350 n2360 DVSS DVSS DVDD DVDD n2340 sky130_fd_sc_hs__nor2_1
XU296 commit_clk_cnt[8] n2340 DVSS DVSS DVDD DVDD n2330
+ sky130_fd_sc_hs__nand2_1
XU297 n2320 n2330 DVSS DVSS DVDD DVDD n2310 sky130_fd_sc_hs__nor2_1
XU298 commit_clk_cnt[10] n2310 DVSS DVSS DVDD DVDD n2300
+ sky130_fd_sc_hs__nand2_1
XU299 n2290 n2300 DVSS DVSS DVDD DVDD n2280 sky130_fd_sc_hs__nor2_1
XU300 commit_clk_cnt[12] n2280 DVSS DVSS DVDD DVDD n2270
+ sky130_fd_sc_hs__nand2_1
XU301 n2260 n2270 DVSS DVSS DVDD DVDD n2250 sky130_fd_sc_hs__nor2_1
XU302 commit_clk_cnt[14] n2250 DVSS DVSS DVDD DVDD n2240
+ sky130_fd_sc_hs__nand2_1
XU303 n2230 n2240 DVSS DVSS DVDD DVDD n2220 sky130_fd_sc_hs__nor2_1
XU304 commit_clk_cnt[16] n2220 DVSS DVSS DVDD DVDD n2210
+ sky130_fd_sc_hs__nand2_1
XU305 n2200 n2210 DVSS DVSS DVDD DVDD n2190 sky130_fd_sc_hs__nor2_1
XU306 commit_clk_cnt[18] n2190 DVSS DVSS DVDD DVDD n2180
+ sky130_fd_sc_hs__nand2_1
XU307 n2170 n2180 DVSS DVSS DVDD DVDD n2160 sky130_fd_sc_hs__nor2_1
XU308 commit_clk_cnt[20] n2160 DVSS DVSS DVDD DVDD n2150
+ sky130_fd_sc_hs__nand2_1
XU309 n2140 n2150 DVSS DVSS DVDD DVDD n2130 sky130_fd_sc_hs__nor2_1
XU310 commit_clk_cnt[22] n2130 DVSS DVSS DVDD DVDD n2120
+ sky130_fd_sc_hs__nand2_1
XU311 n2110 n2120 DVSS DVSS DVDD DVDD n2100 sky130_fd_sc_hs__nor2_1
XU312 commit_clk_cnt[24] n2100 DVSS DVSS DVDD DVDD n2090
+ sky130_fd_sc_hs__nand2_1
XU313 n2080 n2090 DVSS DVSS DVDD DVDD n2070 sky130_fd_sc_hs__nor2_1
XU314 commit_clk_cnt[26] n2070 DVSS DVSS DVDD DVDD n2060
+ sky130_fd_sc_hs__nand2_1
XU315 n2050 n2060 DVSS DVSS DVDD DVDD n204 sky130_fd_sc_hs__nor2_1
XU316 commit_clk_cnt[28] n204 DVSS DVSS DVDD DVDD n203 sky130_fd_sc_hs__nand2_1
XU317 n202 n203 DVSS DVSS DVDD DVDD n201 sky130_fd_sc_hs__nor2_1
XU318 commit_clk_cnt[30] n201 DVSS DVSS DVDD DVDD n2450
+ sky130_fd_sc_hs__nand2_1
XU319 commit_clk_cnt[30] n201 n2450 DVSS DVSS DVDD DVDD N104
+ sky130_fd_sc_hs__o21a_1
XU320 n202 n203 n201 DVSS DVSS DVDD DVDD N103 sky130_fd_sc_hs__a21oi_1
XU321 commit_clk_cnt[28] n204 n203 DVSS DVSS DVDD DVDD N102
+ sky130_fd_sc_hs__o21a_1
XU322 n2050 n2060 n204 DVSS DVSS DVDD DVDD N101 sky130_fd_sc_hs__a21oi_1
XU323 commit_clk_cnt[26] n2070 n2060 DVSS DVSS DVDD DVDD N100
+ sky130_fd_sc_hs__o21a_1
XU324 n2080 n2090 n2070 DVSS DVSS DVDD DVDD N99 sky130_fd_sc_hs__a21oi_1
XU325 commit_clk_cnt[24] n2100 n2090 DVSS DVSS DVDD DVDD N98
+ sky130_fd_sc_hs__o21a_1
XU326 n2110 n2120 n2100 DVSS DVSS DVDD DVDD N97 sky130_fd_sc_hs__a21oi_1
XU327 commit_clk_cnt[22] n2130 n2120 DVSS DVSS DVDD DVDD N96
+ sky130_fd_sc_hs__o21a_1
XU328 n2140 n2150 n2130 DVSS DVSS DVDD DVDD N95 sky130_fd_sc_hs__a21oi_1
XU329 commit_clk_cnt[20] n2160 n2150 DVSS DVSS DVDD DVDD N94
+ sky130_fd_sc_hs__o21a_1
XU330 n2170 n2180 n2160 DVSS DVSS DVDD DVDD N93 sky130_fd_sc_hs__a21oi_1
XU331 commit_clk_cnt[18] n2190 n2180 DVSS DVSS DVDD DVDD N92
+ sky130_fd_sc_hs__o21a_1
XU332 n2200 n2210 n2190 DVSS DVSS DVDD DVDD N91 sky130_fd_sc_hs__a21oi_1
XU333 commit_clk_cnt[16] n2220 n2210 DVSS DVSS DVDD DVDD N90
+ sky130_fd_sc_hs__o21a_1
XU334 n2230 n2240 n2220 DVSS DVSS DVDD DVDD N89 sky130_fd_sc_hs__a21oi_1
XU335 commit_clk_cnt[14] n2250 n2240 DVSS DVSS DVDD DVDD N88
+ sky130_fd_sc_hs__o21a_1
XU336 n2260 n2270 n2250 DVSS DVSS DVDD DVDD N87 sky130_fd_sc_hs__a21oi_1
XU337 commit_clk_cnt[12] n2280 n2270 DVSS DVSS DVDD DVDD N86
+ sky130_fd_sc_hs__o21a_1
XU338 n2290 n2300 n2280 DVSS DVSS DVDD DVDD N85 sky130_fd_sc_hs__a21oi_1
XU339 commit_clk_cnt[10] n2310 n2300 DVSS DVSS DVDD DVDD N84
+ sky130_fd_sc_hs__o21a_1
XU340 n2320 n2330 n2310 DVSS DVSS DVDD DVDD N83 sky130_fd_sc_hs__a21oi_1
XU341 commit_clk_cnt[8] n2340 n2330 DVSS DVSS DVDD DVDD N82
+ sky130_fd_sc_hs__o21a_1
XU342 n2350 n2360 n2340 DVSS DVSS DVDD DVDD N81 sky130_fd_sc_hs__a21oi_1
XU343 commit_clk_cnt[6] n2370 n2360 DVSS DVSS DVDD DVDD N80
+ sky130_fd_sc_hs__o21a_1
XU344 n2380 n2390 n2370 DVSS DVSS DVDD DVDD N79 sky130_fd_sc_hs__a21oi_1
XU345 commit_clk_cnt[4] n2400 n2390 DVSS DVSS DVDD DVDD N78
+ sky130_fd_sc_hs__o21a_1
XU346 n2410 n2420 n2400 DVSS DVSS DVDD DVDD N77 sky130_fd_sc_hs__a21oi_1
XU347 commit_clk_cnt[2] n2430 n2420 DVSS DVSS DVDD DVDD N76
+ sky130_fd_sc_hs__o21a_1
XU348 n2440 N74 n2430 DVSS DVSS DVDD DVDD N75 sky130_fd_sc_hs__a21oi_1
XU349 commit_clk_cnt[31] n2450 DVSS DVSS DVDD DVDD N105
+ sky130_fd_sc_hs__xnor2_1
XU350 stat_error[22] DVSS DVSS DVDD DVDD n3020 sky130_fd_sc_hs__inv_4
XU351 stat_error[20] DVSS DVSS DVDD DVDD n327 sky130_fd_sc_hs__inv_4
XU352 stat_error[18] DVSS DVSS DVDD DVDD n326 sky130_fd_sc_hs__inv_4
XU353 stat_error[16] DVSS DVSS DVDD DVDD n392 sky130_fd_sc_hs__inv_4
XU354 stat_error[14] DVSS DVSS DVDD DVDD n318 sky130_fd_sc_hs__inv_4
XU355 stat_error[12] DVSS DVSS DVDD DVDD n356 sky130_fd_sc_hs__inv_4
XU356 stat_error[10] DVSS DVSS DVDD DVDD n354 sky130_fd_sc_hs__inv_4
XU357 stat_error[8] DVSS DVSS DVDD DVDD n322 sky130_fd_sc_hs__inv_4
XU358 stat_error[6] DVSS DVSS DVDD DVDD n337 sky130_fd_sc_hs__inv_4
XU359 stat_error[4] DVSS DVSS DVDD DVDD n370 sky130_fd_sc_hs__inv_4
XU360 stat_error[2] DVSS DVSS DVDD DVDD n3090 sky130_fd_sc_hs__inv_4
XU361 stat_error[0] DVSS DVSS DVDD DVDD n336 sky130_fd_sc_hs__inv_4
XU362 esample_DR esample_DF DVSS DVSS DVDD DVDD n410 sky130_fd_sc_hs__nor2b_1
XU363 n410 accumu_select DVSS DVSS DVDD DVDD n269 sky130_fd_sc_hs__nand2_1
XU364 n336 n269 DVSS DVSS DVDD DVDD n268 sky130_fd_sc_hs__nor2_1
XU365 stat_error[1] n268 DVSS DVSS DVDD DVDD n267 sky130_fd_sc_hs__nand2_1
XU366 n3090 n267 DVSS DVSS DVDD DVDD n266 sky130_fd_sc_hs__nor2_1
XU367 stat_error[3] n266 DVSS DVSS DVDD DVDD n265 sky130_fd_sc_hs__nand2_1
XU368 n370 n265 DVSS DVSS DVDD DVDD n264 sky130_fd_sc_hs__nor2_1
XU369 stat_error[5] n264 DVSS DVSS DVDD DVDD n263 sky130_fd_sc_hs__nand2_1
XU370 n337 n263 DVSS DVSS DVDD DVDD n262 sky130_fd_sc_hs__nor2_1
XU371 stat_error[7] n262 DVSS DVSS DVDD DVDD n261 sky130_fd_sc_hs__nand2_1
XU372 n322 n261 DVSS DVSS DVDD DVDD n260 sky130_fd_sc_hs__nor2_1
XU373 stat_error[9] n260 DVSS DVSS DVDD DVDD n259 sky130_fd_sc_hs__nand2_1
XU374 n354 n259 DVSS DVSS DVDD DVDD n258 sky130_fd_sc_hs__nor2_1
XU375 stat_error[11] n258 DVSS DVSS DVDD DVDD n257 sky130_fd_sc_hs__nand2_1
XU376 n356 n257 DVSS DVSS DVDD DVDD n256 sky130_fd_sc_hs__nor2_1
XU377 stat_error[13] n256 DVSS DVSS DVDD DVDD n255 sky130_fd_sc_hs__nand2_1
XU378 n318 n255 DVSS DVSS DVDD DVDD n2540 sky130_fd_sc_hs__nor2_1
XU379 stat_error[15] n2540 DVSS DVSS DVDD DVDD n2530 sky130_fd_sc_hs__nand2_1
XU380 n392 n2530 DVSS DVSS DVDD DVDD n2520 sky130_fd_sc_hs__nor2_1
XU381 stat_error[17] n2520 DVSS DVSS DVDD DVDD n2510 sky130_fd_sc_hs__nand2_1
XU382 n326 n2510 DVSS DVSS DVDD DVDD n2500 sky130_fd_sc_hs__nor2_1
XU383 stat_error[19] n2500 DVSS DVSS DVDD DVDD n2490 sky130_fd_sc_hs__nand2_1
XU384 n327 n2490 DVSS DVSS DVDD DVDD n2480 sky130_fd_sc_hs__nor2_1
XU385 stat_error[21] n2480 DVSS DVSS DVDD DVDD n2470 sky130_fd_sc_hs__nand2_1
XU386 n3020 n2470 DVSS DVSS DVDD DVDD n2460 sky130_fd_sc_hs__nor2_1
XU387 stat_error[23] n2460 DVSS DVSS DVDD DVDD n270 sky130_fd_sc_hs__nand2_1
XU388 stat_error[23] n2460 n270 DVSS DVSS DVDD DVDD N228
+ sky130_fd_sc_hs__o21a_1
XU389 n3020 n2470 n2460 DVSS DVSS DVDD DVDD N227 sky130_fd_sc_hs__a21oi_1
XU390 stat_error[21] n2480 n2470 DVSS DVSS DVDD DVDD N226
+ sky130_fd_sc_hs__o21a_1
XU391 n327 n2490 n2480 DVSS DVSS DVDD DVDD N225 sky130_fd_sc_hs__a21oi_1
XU392 stat_error[19] n2500 n2490 DVSS DVSS DVDD DVDD N224
+ sky130_fd_sc_hs__o21a_1
XU393 n326 n2510 n2500 DVSS DVSS DVDD DVDD N223 sky130_fd_sc_hs__a21oi_1
XU394 stat_error[17] n2520 n2510 DVSS DVSS DVDD DVDD N222
+ sky130_fd_sc_hs__o21a_1
XU395 n392 n2530 n2520 DVSS DVSS DVDD DVDD N221 sky130_fd_sc_hs__a21oi_1
XU396 stat_error[15] n2540 n2530 DVSS DVSS DVDD DVDD N220
+ sky130_fd_sc_hs__o21a_1
XU397 n318 n255 n2540 DVSS DVSS DVDD DVDD N219 sky130_fd_sc_hs__a21oi_1
XU398 stat_error[13] n256 n255 DVSS DVSS DVDD DVDD N218 sky130_fd_sc_hs__o21a_1
XU399 n356 n257 n256 DVSS DVSS DVDD DVDD N217 sky130_fd_sc_hs__a21oi_1
XU400 stat_error[11] n258 n257 DVSS DVSS DVDD DVDD N216 sky130_fd_sc_hs__o21a_1
XU401 n354 n259 n258 DVSS DVSS DVDD DVDD N215 sky130_fd_sc_hs__a21oi_1
XU402 stat_error[9] n260 n259 DVSS DVSS DVDD DVDD N214 sky130_fd_sc_hs__o21a_1
XU403 n322 n261 n260 DVSS DVSS DVDD DVDD N213 sky130_fd_sc_hs__a21oi_1
XU404 stat_error[7] n262 n261 DVSS DVSS DVDD DVDD N212 sky130_fd_sc_hs__o21a_1
XU405 n337 n263 n262 DVSS DVSS DVDD DVDD N211 sky130_fd_sc_hs__a21oi_1
XU406 stat_error[5] n264 n263 DVSS DVSS DVDD DVDD N210 sky130_fd_sc_hs__o21a_1
XU407 n370 n265 n264 DVSS DVSS DVDD DVDD N209 sky130_fd_sc_hs__a21oi_1
XU408 stat_error[3] n266 n265 DVSS DVSS DVDD DVDD N208 sky130_fd_sc_hs__o21a_1
XU409 n3090 n267 n266 DVSS DVSS DVDD DVDD N207 sky130_fd_sc_hs__a21oi_1
XU410 stat_error[1] n268 n267 DVSS DVSS DVDD DVDD N206 sky130_fd_sc_hs__o21a_1
XU411 n336 n269 n268 DVSS DVSS DVDD DVDD N205 sky130_fd_sc_hs__a21oi_1
XU412 stat_error[24] n270 DVSS DVSS DVDD DVDD N229 sky130_fd_sc_hs__xnor2_1
XU413 stat_clean[22] DVSS DVSS DVDD DVDD n324 sky130_fd_sc_hs__inv_4
XU414 stat_clean[20] DVSS DVSS DVDD DVDD n3030 sky130_fd_sc_hs__inv_4
XU415 stat_clean[18] DVSS DVSS DVDD DVDD n276 sky130_fd_sc_hs__inv_4
XU416 stat_clean[16] DVSS DVSS DVDD DVDD n3050 sky130_fd_sc_hs__inv_4
XU417 stat_clean[14] DVSS DVSS DVDD DVDD n281 sky130_fd_sc_hs__inv_4
XU418 stat_clean[12] DVSS DVSS DVDD DVDD n320 sky130_fd_sc_hs__inv_4
XU419 stat_clean[10] DVSS DVSS DVDD DVDD n3070 sky130_fd_sc_hs__inv_4
XU420 stat_clean[8] DVSS DVSS DVDD DVDD n288 sky130_fd_sc_hs__inv_4
XU421 stat_clean[6] DVSS DVSS DVDD DVDD n330 sky130_fd_sc_hs__inv_4
XU422 stat_clean[4] DVSS DVSS DVDD DVDD n313 sky130_fd_sc_hs__inv_4
XU423 stat_clean[2] DVSS DVSS DVDD DVDD n295 sky130_fd_sc_hs__inv_4
XU424 stat_clean[0] DVSS DVSS DVDD DVDD n2990 sky130_fd_sc_hs__inv_4
XU425 accumu_select n410 DVSS DVSS DVDD DVDD n298 sky130_fd_sc_hs__nand2b_1
XU426 n2990 n298 DVSS DVSS DVDD DVDD n297 sky130_fd_sc_hs__nor2_1
XU427 stat_clean[1] n297 DVSS DVSS DVDD DVDD n296 sky130_fd_sc_hs__nand2_1
XU428 n295 n296 DVSS DVSS DVDD DVDD n294 sky130_fd_sc_hs__nor2_1
XU429 stat_clean[3] n294 DVSS DVSS DVDD DVDD n293 sky130_fd_sc_hs__nand2_1
XU430 n313 n293 DVSS DVSS DVDD DVDD n292 sky130_fd_sc_hs__nor2_1
XU431 stat_clean[5] n292 DVSS DVSS DVDD DVDD n291 sky130_fd_sc_hs__nand2_1
XU432 n330 n291 DVSS DVSS DVDD DVDD n290 sky130_fd_sc_hs__nor2_1
XU433 stat_clean[7] n290 DVSS DVSS DVDD DVDD n289 sky130_fd_sc_hs__nand2_1
XU434 n288 n289 DVSS DVSS DVDD DVDD n287 sky130_fd_sc_hs__nor2_1
XU435 stat_clean[9] n287 DVSS DVSS DVDD DVDD n286 sky130_fd_sc_hs__nand2_1
XU436 n3070 n286 DVSS DVSS DVDD DVDD n285 sky130_fd_sc_hs__nor2_1
XU437 stat_clean[11] n285 DVSS DVSS DVDD DVDD n284 sky130_fd_sc_hs__nand2_1
XU438 n320 n284 DVSS DVSS DVDD DVDD n283 sky130_fd_sc_hs__nor2_1
XU439 stat_clean[13] n283 DVSS DVSS DVDD DVDD n282 sky130_fd_sc_hs__nand2_1
XU440 n281 n282 DVSS DVSS DVDD DVDD n280 sky130_fd_sc_hs__nor2_1
XU441 stat_clean[15] n280 DVSS DVSS DVDD DVDD n279 sky130_fd_sc_hs__nand2_1
XU442 n3050 n279 DVSS DVSS DVDD DVDD n278 sky130_fd_sc_hs__nor2_1
XU443 stat_clean[17] n278 DVSS DVSS DVDD DVDD n277 sky130_fd_sc_hs__nand2_1
XU444 n276 n277 DVSS DVSS DVDD DVDD n275 sky130_fd_sc_hs__nor2_1
XU445 stat_clean[19] n275 DVSS DVSS DVDD DVDD n274 sky130_fd_sc_hs__nand2_1
XU446 n3030 n274 DVSS DVSS DVDD DVDD n273 sky130_fd_sc_hs__nor2_1
XU447 stat_clean[21] n273 DVSS DVSS DVDD DVDD n272 sky130_fd_sc_hs__nand2_1
XU448 n324 n272 DVSS DVSS DVDD DVDD n271 sky130_fd_sc_hs__nor2_1
XU449 stat_clean[23] n271 DVSS DVSS DVDD DVDD n3000 sky130_fd_sc_hs__nand2_1
XU450 stat_clean[23] n271 n3000 DVSS DVSS DVDD DVDD N253
+ sky130_fd_sc_hs__o21a_1
XU451 n324 n272 n271 DVSS DVSS DVDD DVDD N252 sky130_fd_sc_hs__a21oi_1
XU452 stat_clean[21] n273 n272 DVSS DVSS DVDD DVDD N251 sky130_fd_sc_hs__o21a_1
XU453 n3030 n274 n273 DVSS DVSS DVDD DVDD N250 sky130_fd_sc_hs__a21oi_1
XU454 stat_clean[19] n275 n274 DVSS DVSS DVDD DVDD N249 sky130_fd_sc_hs__o21a_1
XU455 n276 n277 n275 DVSS DVSS DVDD DVDD N248 sky130_fd_sc_hs__a21oi_1
XU456 stat_clean[17] n278 n277 DVSS DVSS DVDD DVDD N247 sky130_fd_sc_hs__o21a_1
XU457 n3050 n279 n278 DVSS DVSS DVDD DVDD N246 sky130_fd_sc_hs__a21oi_1
XU458 stat_clean[15] n280 n279 DVSS DVSS DVDD DVDD N245 sky130_fd_sc_hs__o21a_1
XU459 n281 n282 n280 DVSS DVSS DVDD DVDD N244 sky130_fd_sc_hs__a21oi_1
XU460 stat_clean[13] n283 n282 DVSS DVSS DVDD DVDD N243 sky130_fd_sc_hs__o21a_1
XU461 n320 n284 n283 DVSS DVSS DVDD DVDD N242 sky130_fd_sc_hs__a21oi_1
XU462 stat_clean[11] n285 n284 DVSS DVSS DVDD DVDD N241 sky130_fd_sc_hs__o21a_1
XU463 n3070 n286 n285 DVSS DVSS DVDD DVDD N240 sky130_fd_sc_hs__a21oi_1
XU464 stat_clean[9] n287 n286 DVSS DVSS DVDD DVDD N239 sky130_fd_sc_hs__o21a_1
XU465 n288 n289 n287 DVSS DVSS DVDD DVDD N238 sky130_fd_sc_hs__a21oi_1
XU466 stat_clean[7] n290 n289 DVSS DVSS DVDD DVDD N237 sky130_fd_sc_hs__o21a_1
XU467 n330 n291 n290 DVSS DVSS DVDD DVDD N236 sky130_fd_sc_hs__a21oi_1
XU468 stat_clean[5] n292 n291 DVSS DVSS DVDD DVDD N235 sky130_fd_sc_hs__o21a_1
XU469 n313 n293 n292 DVSS DVSS DVDD DVDD N234 sky130_fd_sc_hs__a21oi_1
XU470 stat_clean[3] n294 n293 DVSS DVSS DVDD DVDD N233 sky130_fd_sc_hs__o21a_1
XU471 n295 n296 n294 DVSS DVSS DVDD DVDD N232 sky130_fd_sc_hs__a21oi_1
XU472 stat_clean[1] n297 n296 DVSS DVSS DVDD DVDD N231 sky130_fd_sc_hs__o21a_1
XU473 n2990 n298 n297 DVSS DVSS DVDD DVDD N230 sky130_fd_sc_hs__a21oi_1
XU474 stat_clean[24] n3000 DVSS DVSS DVDD DVDD N254 sky130_fd_sc_hs__xnor2_1
XU475 stat_error[23] DVSS DVSS DVDD DVDD n344 sky130_fd_sc_hs__inv_4
XU476 stat_error[3] DVSS DVSS DVDD DVDD n361 sky130_fd_sc_hs__inv_4
XU477 stat_error[1] DVSS DVSS DVDD DVDD n3120 sky130_fd_sc_hs__inv_4
XU478 n3090 stat_clean[2] n3120 stat_clean[1] DVSS DVSS DVDD DVDD n3010
+ sky130_fd_sc_hs__a22o_1
XU479 stat_clean[3] n361 n3010 DVSS DVSS DVDD DVDD n363
+ sky130_fd_sc_hs__a21oi_1
XU480 stat_error[13] DVSS DVSS DVDD DVDD n317 sky130_fd_sc_hs__inv_4
XU481 stat_clean[13] n317 stat_clean[12] n356 DVSS DVSS DVDD DVDD n357
+ sky130_fd_sc_hs__o22ai_1
XU482 stat_error[19] DVSS DVSS DVDD DVDD n397 sky130_fd_sc_hs__inv_4
XU483 stat_clean[22] n3020 stat_clean[23] n344 DVSS DVSS DVDD DVDD n390
+ sky130_fd_sc_hs__a22oi_1
XU484 stat_error[21] DVSS DVSS DVDD DVDD n328 sky130_fd_sc_hs__inv_4
XU485 stat_clean[21] n328 DVSS DVSS DVDD DVDD n388 sky130_fd_sc_hs__nand2_1
XU486 stat_error[20] n3030 n390 n388 DVSS DVSS DVDD DVDD n400
+ sky130_fd_sc_hs__o211ai_1
XU487 stat_clean[19] n397 n400 DVSS DVSS DVDD DVDD n3040
+ sky130_fd_sc_hs__a21oi_1
XU488 stat_clean[18] n326 DVSS DVSS DVDD DVDD n396 sky130_fd_sc_hs__nand2_1
XU489 stat_error[16] n3050 n3040 n396 DVSS DVSS DVDD DVDD n383
+ sky130_fd_sc_hs__o211ai_1
XU490 n357 n383 DVSS DVSS DVDD DVDD n3060 sky130_fd_sc_hs__nor2_1
XU491 stat_clean[23] n344 n363 n3060 DVSS DVSS DVDD DVDD n342
+ sky130_fd_sc_hs__o211ai_1
XU492 stat_clean[24] DVSS DVSS DVDD DVDD n325 sky130_fd_sc_hs__inv_4
XU493 stat_error[24] n325 DVSS DVSS DVDD DVDD n406 sky130_fd_sc_hs__nor2_1
XU494 stat_error[10] n3070 DVSS DVSS DVDD DVDD n3080 sky130_fd_sc_hs__nor2_1
XU495 stat_clean[14] n318 DVSS DVSS DVDD DVDD n348 sky130_fd_sc_hs__nor2_1
XU496 stat_error[15] DVSS DVSS DVDD DVDD n345 sky130_fd_sc_hs__inv_4
XU497 stat_clean[15] n345 DVSS DVSS DVDD DVDD n346 sky130_fd_sc_hs__nor2_1
XU498 n406 n3080 n348 n346 DVSS DVSS DVDD DVDD n316 sky130_fd_sc_hs__nor4_1
XU499 stat_clean[10] n354 DVSS DVSS DVDD DVDD n3100 sky130_fd_sc_hs__nor2_1
XU500 stat_clean[11] stat_error[11] DVSS DVSS DVDD DVDD n351
+ sky130_fd_sc_hs__nor2b_1
XU501 stat_clean[2] n3090 DVSS DVSS DVDD DVDD n365 sky130_fd_sc_hs__nor2_1
XU502 n3100 n351 n365 DVSS DVSS DVDD DVDD n315 sky130_fd_sc_hs__nor3_1
XU503 stat_error[9] DVSS DVSS DVDD DVDD n311 sky130_fd_sc_hs__inv_4
XU504 stat_clean[9] n311 stat_clean[8] n322 DVSS DVSS DVDD DVDD n352
+ sky130_fd_sc_hs__o22ai_1
XU505 stat_clean[11] DVSS DVSS DVDD DVDD n349 sky130_fd_sc_hs__inv_4
XU506 n311 stat_clean[9] stat_error[11] n349 DVSS DVSS DVDD DVDD n350
+ sky130_fd_sc_hs__o2bb2ai_1
XU507 stat_clean[1] n3120 stat_clean[0] n336 DVSS DVSS DVDD DVDD n362
+ sky130_fd_sc_hs__o22ai_1
XU508 stat_clean[5] DVSS DVSS DVDD DVDD n369 sky130_fd_sc_hs__inv_4
XU509 stat_error[4] n313 stat_error[5] n369 DVSS DVSS DVDD DVDD n366
+ sky130_fd_sc_hs__o22ai_1
XU510 n352 n350 n362 n366 DVSS DVSS DVDD DVDD n314 sky130_fd_sc_hs__nor4_1
XU511 stat_clean[3] n361 DVSS DVSS DVDD DVDD n367 sky130_fd_sc_hs__or2_1
XU512 n316 n315 n314 n367 DVSS DVSS DVDD DVDD n341 sky130_fd_sc_hs__nand4_1
XU513 n318 stat_clean[14] n317 stat_clean[13] DVSS DVSS DVDD DVDD n319
+ sky130_fd_sc_hs__a22o_1
XU514 stat_clean[15] n345 n319 DVSS DVSS DVDD DVDD n359
+ sky130_fd_sc_hs__a21oi_1
XU515 stat_error[12] n320 n359 DVSS DVSS DVDD DVDD n321
+ sky130_fd_sc_hs__o21ai_1
XU516 stat_clean[8] n322 n321 DVSS DVSS DVDD DVDD n379 sky130_fd_sc_hs__a21oi_1
XU517 stat_clean[5] stat_error[5] DVSS DVSS DVDD DVDD n374
+ sky130_fd_sc_hs__nor2b_1
XU518 stat_clean[4] n370 DVSS DVSS DVDD DVDD n323 sky130_fd_sc_hs__nor2_1
XU519 stat_error[7] stat_clean[7] DVSS DVSS DVDD DVDD n376
+ sky130_fd_sc_hs__nor2b_1
XU520 n374 n323 n376 DVSS DVSS DVDD DVDD n339 sky130_fd_sc_hs__nor3_1
XU521 stat_error[22] n324 DVSS DVSS DVDD DVDD n343 sky130_fd_sc_hs__nand2_1
XU522 stat_error[24] n325 DVSS DVSS DVDD DVDD n407 sky130_fd_sc_hs__nand2_1
XU523 stat_clean[19] n397 n343 n407 DVSS DVSS DVDD DVDD n335
+ sky130_fd_sc_hs__o211ai_1
XU524 stat_clean[7] stat_error[7] DVSS DVSS DVDD DVDD n382
+ sky130_fd_sc_hs__nor2b_1
XU525 stat_clean[17] DVSS DVSS DVDD DVDD n331 sky130_fd_sc_hs__inv_4
XU526 n331 stat_error[17] DVSS DVSS DVDD DVDD n393 sky130_fd_sc_hs__nor2_1
XU527 stat_clean[18] n326 DVSS DVSS DVDD DVDD n394 sky130_fd_sc_hs__nor2_1
XU528 n382 n393 n394 DVSS DVSS DVDD DVDD n333 sky130_fd_sc_hs__nor3_1
XU529 stat_clean[16] n392 DVSS DVSS DVDD DVDD n329 sky130_fd_sc_hs__nor2_1
XU530 stat_clean[20] n327 DVSS DVSS DVDD DVDD n389 sky130_fd_sc_hs__nor2_1
XU531 stat_clean[21] n328 DVSS DVSS DVDD DVDD n387 sky130_fd_sc_hs__nor2_1
XU532 n329 n389 n387 DVSS DVSS DVDD DVDD n332 sky130_fd_sc_hs__nor3_1
XU533 stat_error[6] n330 DVSS DVSS DVDD DVDD n377 sky130_fd_sc_hs__nand2_1
XU534 stat_error[17] n331 DVSS DVSS DVDD DVDD n391 sky130_fd_sc_hs__nand2_1
XU535 n333 n332 n377 n391 DVSS DVSS DVDD DVDD n334 sky130_fd_sc_hs__nand4_1
XU536 stat_clean[0] n336 n335 n334 DVSS DVSS DVDD DVDD n338
+ sky130_fd_sc_hs__a211oi_1
XU537 stat_clean[6] n337 DVSS DVSS DVDD DVDD n372 sky130_fd_sc_hs__nand2_1
XU538 n379 n339 n338 n372 DVSS DVSS DVDD DVDD n340 sky130_fd_sc_hs__nand4_1
XU539 n342 n341 n340 DVSS DVSS DVDD DVDD n444 sky130_fd_sc_hs__nor3_1
XU540 stat_clean[23] n344 n343 DVSS DVSS DVDD DVDD n409 sky130_fd_sc_hs__maj3_1
XU541 stat_clean[15] n345 DVSS DVSS DVDD DVDD n347 sky130_fd_sc_hs__nand2_1
XU542 n348 n347 n346 DVSS DVSS DVDD DVDD n386 sky130_fd_sc_hs__a21oi_1
XU543 stat_error[11] n349 DVSS DVSS DVDD DVDD n355 sky130_fd_sc_hs__nor2_1
XU544 stat_clean[10] n354 n350 DVSS DVSS DVDD DVDD n380
+ sky130_fd_sc_hs__a21oi_1
XU545 n380 n352 n351 DVSS DVSS DVDD DVDD n353 sky130_fd_sc_hs__a21oi_1
XU546 stat_clean[10] n355 n354 n353 DVSS DVSS DVDD DVDD n360
+ sky130_fd_sc_hs__o31ai_1
XU547 stat_clean[12] n356 DVSS DVSS DVDD DVDD n358 sky130_fd_sc_hs__nand2_1
XU548 n360 n359 n358 n357 n359 DVSS DVSS DVDD DVDD n385
+ sky130_fd_sc_hs__a32oi_1
XU549 stat_clean[3] n361 DVSS DVSS DVDD DVDD n364 sky130_fd_sc_hs__nand2_1
XU550 n365 n364 n363 n362 DVSS DVSS DVDD DVDD n368 sky130_fd_sc_hs__a22oi_1
XU551 n368 n367 n366 DVSS DVSS DVDD DVDD n375 sky130_fd_sc_hs__a21oi_1
XU552 stat_error[5] n369 DVSS DVSS DVDD DVDD n371 sky130_fd_sc_hs__nor2_1
XU553 stat_clean[4] n371 n370 DVSS DVSS DVDD DVDD n373 sky130_fd_sc_hs__nor3_1
XU554 n375 n374 n373 n372 DVSS DVSS DVDD DVDD n378 sky130_fd_sc_hs__o31ai_1
XU555 n378 n377 n376 DVSS DVSS DVDD DVDD n381 sky130_fd_sc_hs__a21oi_1
XU556 n382 n381 n380 n379 DVSS DVSS DVDD DVDD n384 sky130_fd_sc_hs__o211ai_1
XU557 n386 n385 n384 n383 DVSS DVSS DVDD DVDD n405 sky130_fd_sc_hs__a31oi_2
XU558 n393 DVSS DVSS DVDD DVDD n404 sky130_fd_sc_hs__inv_4
XU559 n389 n388 n387 DVSS DVSS DVDD DVDD n402 sky130_fd_sc_hs__a21oi_1
XU560 n390 DVSS DVSS DVDD DVDD n401 sky130_fd_sc_hs__inv_4
XU561 stat_clean[16] n393 n392 n391 DVSS DVSS DVDD DVDD n395
+ sky130_fd_sc_hs__o31ai_1
XU562 n396 n395 n394 DVSS DVSS DVDD DVDD n398 sky130_fd_sc_hs__a21oi_1
XU563 stat_clean[19] n398 n397 DVSS DVSS DVDD DVDD n399 sky130_fd_sc_hs__maj3_1
XU564 n402 n401 n400 n399 DVSS DVSS DVDD DVDD n403 sky130_fd_sc_hs__o22ai_1
XU565 n405 n404 n403 DVSS DVSS DVDD DVDD n408 sky130_fd_sc_hs__a21oi_1
XU566 n409 n408 n407 n406 DVSS DVSS DVDD DVDD n445 sky130_fd_sc_hs__a31oi_1
XU567 n410 aux_clk_out DVSS DVSS DVDD DVDD esample_N2 sky130_fd_sc_hs__nor2b_1
XU568 CurrentState_1_ n970 DVSS DVSS DVDD DVDD N312 sky130_fd_sc_hs__nand2_1
XU570 fftl_en osc_fine_con[0] n447 manual_control_osc[0] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[0] sky130_fd_sc_hs__a22o_1
XU571 fftl_en osc_fine_con[1] n447 manual_control_osc[1] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[1] sky130_fd_sc_hs__a22o_1
XU572 fftl_en osc_fine_con[2] n447 manual_control_osc[2] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[2] sky130_fd_sc_hs__a22o_1
XU573 fftl_en osc_fine_con[3] n447 manual_control_osc[3] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[3] sky130_fd_sc_hs__a22o_1
XU574 fftl_en osc_fine_con[4] n447 manual_control_osc[4] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[4] sky130_fd_sc_hs__a22o_1
XU575 fftl_en osc_fine_con[5] n447 manual_control_osc[5] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[5] sky130_fd_sc_hs__a22o_1
XU576 fftl_en osc_fine_con[6] n447 manual_control_osc[6] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[6] sky130_fd_sc_hs__a22o_1
XU577 fftl_en osc_fine_con[7] n447 manual_control_osc[7] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[7] sky130_fd_sc_hs__a22o_1
XU578 fftl_en osc_fine_con[8] n447 manual_control_osc[8] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[8] sky130_fd_sc_hs__a22o_1
XU579 fftl_en osc_fine_con[9] n447 manual_control_osc[9] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[9] sky130_fd_sc_hs__a22o_1
XU580 fftl_en osc_fine_con[10] n447 manual_control_osc[10] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[10] sky130_fd_sc_hs__a22o_1
XU581 fftl_en osc_fine_con[11] n447 manual_control_osc[11] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[11] sky130_fd_sc_hs__a22o_1
XU582 fftl_en osc_fine_con[12] n447 manual_control_osc[12] DVSS DVSS DVDD DVDD
+ osc_fine_con_final[12] sky130_fd_sc_hs__a22o_1
XU583 fine_control_avg_window_select[2] n414 n413 n412
+ fine_control_avg_window_select[1] DVSS DVSS DVDD DVDD n432
+ sky130_fd_sc_hs__a32oi_1
XU584 n418 n417 n416 n415 n417 DVSS DVSS DVDD DVDD n430
+ sky130_fd_sc_hs__a32oi_1
XU585 fine_control_avg_window_select[1] fine_control_avg_window_select[2] DVSS
+ DVSS DVDD DVDD n429 sky130_fd_sc_hs__nor2_1
XU586 commit_clk_cnt[16] n420 commit_clk_cnt[8] n419 DVSS DVSS DVDD DVDD n427
+ sky130_fd_sc_hs__a22oi_1
XU587 n421 n423 commit_clk_cnt[24] DVSS DVSS DVDD DVDD n425
+ sky130_fd_sc_hs__o21ai_1
XU588 commit_clk_cnt[1] n423 n422 DVSS DVSS DVDD DVDD n424
+ sky130_fd_sc_hs__a21oi_1
XU589 n427 n426 n425 n424 fine_control_avg_window_select[0] DVSS DVSS DVDD DVDD
+ n428 sky130_fd_sc_hs__a32oi_1
XU590 fine_control_avg_window_select[0] n430 n429 n428 DVSS DVSS DVDD DVDD n431
+ sky130_fd_sc_hs__a22oi_1
XU591 fine_control_avg_window_select[0] n432 n431 DVSS DVSS DVDD DVDD
+ commit_clk sky130_fd_sc_hs__o21ai_1
XU231 n426 n182 rst n181 DVSS DVSS DVDD DVDD n184 sky130_fd_sc_hs__a211oi_4
XCurrentState_reg_0_ commit_clk NextState[0] n448 DVSS DVSS DVDD DVDD 1032 n970
+ sky130_fd_sc_hs__dfsbp_2
XNextState_reg_1_ commit_clk n444 n448 DVSS DVSS DVDD DVDD NextState[1]
+ sky130_fd_sc_hs__dfstp_2
Xcommit_clk_cnt_reg_0_ accumu_select N74 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[0] sky130_fd_sc_hs__dfrtp_4
XNextState_reg_0_ commit_clk n445 n448 DVSS DVSS DVDD DVDD NextState[0]
+ sky130_fd_sc_hs__dfstp_2
Xcommit_clk_cnt_reg_13_ accumu_select N87 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[13] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_1_ accumu_select N75 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[1] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_23_ accumu_select N97 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[23] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_15_ accumu_select N89 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[15] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_11_ accumu_select N85 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[11] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_21_ accumu_select N95 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[21] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_19_ accumu_select N93 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[19] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_17_ accumu_select N91 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[17] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_5_ accumu_select N79 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[5] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_27_ accumu_select N101 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[27] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_4_ accumu_select N78 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[4] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_14_ accumu_select N88 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[14] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_12_ accumu_select N86 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[12] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_25_ accumu_select N99 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[25] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_7_ accumu_select N81 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[7] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_6_ accumu_select N80 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[6] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_20_ accumu_select N94 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[20] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_9_ accumu_select N83 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[9] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_3_ accumu_select N77 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[3] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_18_ accumu_select N92 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[18] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_29_ accumu_select N103 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[29] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_22_ accumu_select N96 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[22] sky130_fd_sc_hs__dfrtp_4
Xstat_clean_reg_11_ FE_OFN0_ref_clk N241 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ stat_clean[11] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_28_ accumu_select N102 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[28] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_10_ accumu_select N84 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[10] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_1_ net856 N300 n448 DVSS DVSS DVDD DVDD osc_fine_con[1]
+ sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_24_ accumu_select N98 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[24] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_16_ accumu_select N90 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[16] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_12_ net856 n446 n448 DVSS DVSS DVDD DVDD osc_fine_con[12]
+ sky130_fd_sc_hs__dfstp_2
Xosc_fine_con_reg_10_ net856 N309 n448 DVSS DVSS DVDD DVDD osc_fine_con[10]
+ sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_26_ accumu_select N100 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[26] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_9_ net856 N308 n448 DVSS DVSS DVDD DVDD osc_fine_con[9]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_0_ net856 N299 n448 DVSS DVSS DVDD DVDD osc_fine_con[0]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_8_ net856 N307 n448 DVSS DVSS DVDD DVDD osc_fine_con[8]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_11_ net856 N310 n448 DVSS DVSS DVDD DVDD osc_fine_con[11]
+ sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_2_ accumu_select N76 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[2] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_6_ net856 N305 n448 DVSS DVSS DVDD DVDD osc_fine_con[6]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_2_ net856 N301 n448 DVSS DVSS DVDD DVDD osc_fine_con[2]
+ sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_31_ accumu_select N105 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[31] sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_30_ accumu_select N104 n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[30] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_7_ net856 N306 n448 DVSS DVSS DVDD DVDD osc_fine_con[7]
+ sky130_fd_sc_hs__dfrtp_4
Xcommit_clk_cnt_reg_8_ accumu_select N82 FE_OFN1_n184 DVSS DVSS DVDD DVDD
+ commit_clk_cnt[8] sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_3_ net856 N302 n448 DVSS DVSS DVDD DVDD osc_fine_con[3]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_5_ net856 N304 n448 DVSS DVSS DVDD DVDD osc_fine_con[5]
+ sky130_fd_sc_hs__dfrtp_4
Xosc_fine_con_reg_4_ net856 N303 n448 DVSS DVSS DVDD DVDD osc_fine_con[4]
+ sky130_fd_sc_hs__dfrtp_4
XCurrentState_reg_1_ commit_clk NextState[1] n448 DVSS DVSS DVDD DVDD
+ CurrentState_1_ sky130_fd_sc_hs__dfstp_2
Xaccumu_select_reg clk_out ref_clk n448 DVSS DVSS DVDD DVDD accumu_select
+ sky130_fd_sc_hs__dfrtp_4
Xosc_clk_count_reg_0_ net845 n13 DVSS DVSS DVDD DVDD osc_clk_count[0]
+ sky130_fd_sc_hs__dfxtp_2
Xosc_clk_count_reg_4_ net845 n9 DVSS DVSS DVDD DVDD osc_clk_count[4]
+ sky130_fd_sc_hs__dfxtp_4
Xosc_clk_count_reg_1_ net845 n12 DVSS DVSS DVDD DVDD osc_clk_count[1]
+ sky130_fd_sc_hs__dfxtp_2
XU170 n143 n142 DVSS DVSS DVDD DVDD n150 sky130_fd_sc_hs__nor2_2
XR_0 net845 n10 DVSS DVSS DVDD DVDD osc_clk_count[3] sky130_fd_sc_hs__dfxtp_2
XR_1 net845 n433 DVSS DVSS DVDD DVDD n441 sky130_fd_sc_hs__dfxtp_2
XU267 n10 DVSS DVSS DVDD DVDD n433 sky130_fd_sc_hs__inv_2
XU232 rst DVSS DVSS DVDD DVDD n448 sky130_fd_sc_hs__inv_4
XU178 fftl_en DVSS DVSS DVDD DVDD n447 sky130_fd_sc_hs__inv_4
.ENDS

.SUBCKT phase_interpolator_4 l_phase r_phase l_con[3] l_con[2] l_con[1]
+ l_con[0] r_con[3] r_con[2] r_con[1] r_con[0] ckout DVDD DVSS
Xbuf_l l_phase DVSS DVSS DVDD DVDD l_phase_buf sky130_fd_sc_hs__inv_4
Xbuf_r r_phase DVSS DVSS DVDD DVDD r_phase_buf sky130_fd_sc_hs__inv_4
Xblend_left_0 l_phase_buf l_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_left_1 l_phase_buf l_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_left_2 l_phase_buf l_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_left_3 l_phase_buf l_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xblend_right_0 r_phase_buf r_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_right_1 r_phase_buf r_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_right_2 r_phase_buf r_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_right_3 r_phase_buf r_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xout_buf phaseout DVSS DVSS DVDD DVDD ckout sky130_fd_sc_hs__inv_8
.ENDS

.SUBCKT phase_interpolator_3 l_phase r_phase l_con[3] l_con[2] l_con[1]
+ l_con[0] r_con[3] r_con[2] r_con[1] r_con[0] ckout DVDD DVSS
Xbuf_l l_phase DVSS DVSS DVDD DVDD l_phase_buf sky130_fd_sc_hs__inv_4
Xbuf_r r_phase DVSS DVSS DVDD DVDD r_phase_buf sky130_fd_sc_hs__inv_4
Xblend_left_0 l_phase_buf l_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_left_1 l_phase_buf l_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_left_2 l_phase_buf l_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_left_3 l_phase_buf l_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xblend_right_0 r_phase_buf r_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_right_1 r_phase_buf r_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_right_2 r_phase_buf r_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_right_3 r_phase_buf r_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xout_buf phaseout DVSS DVSS DVDD DVDD ckout sky130_fd_sc_hs__inv_8
.ENDS

.SUBCKT phase_interpolator_2 l_phase r_phase l_con[3] l_con[2] l_con[1]
+ l_con[0] r_con[3] r_con[2] r_con[1] r_con[0] ckout DVDD DVSS
Xbuf_l l_phase DVSS DVSS DVDD DVDD l_phase_buf sky130_fd_sc_hs__inv_4
Xbuf_r r_phase DVSS DVSS DVDD DVDD r_phase_buf sky130_fd_sc_hs__inv_4
Xblend_left_0 l_phase_buf l_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_left_1 l_phase_buf l_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_left_2 l_phase_buf l_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_left_3 l_phase_buf l_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xblend_right_0 r_phase_buf r_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_right_1 r_phase_buf r_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_right_2 r_phase_buf r_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_right_3 r_phase_buf r_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xout_buf phaseout DVSS DVSS DVDD DVDD ckout sky130_fd_sc_hs__inv_8
.ENDS

.SUBCKT phase_interpolator_1 l_phase r_phase l_con[3] l_con[2] l_con[1]
+ l_con[0] r_con[3] r_con[2] r_con[1] r_con[0] ckout DVDD DVSS
Xbuf_l l_phase DVSS DVSS DVDD DVDD l_phase_buf sky130_fd_sc_hs__inv_4
Xbuf_r r_phase DVSS DVSS DVDD DVDD r_phase_buf sky130_fd_sc_hs__inv_4
Xblend_left_0 l_phase_buf l_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_left_1 l_phase_buf l_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_left_2 l_phase_buf l_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_left_3 l_phase_buf l_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xblend_right_0 r_phase_buf r_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_right_1 r_phase_buf r_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_right_2 r_phase_buf r_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_right_3 r_phase_buf r_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xout_buf phaseout DVSS DVSS DVDD DVDD ckout sky130_fd_sc_hs__inv_8
.ENDS

.SUBCKT phase_interpolator_0 l_phase r_phase l_con[3] l_con[2] l_con[1]
+ l_con[0] r_con[3] r_con[2] r_con[1] r_con[0] ckout DVDD DVSS
Xbuf_l l_phase DVSS DVSS DVDD DVDD l_phase_buf sky130_fd_sc_hs__inv_4
Xbuf_r r_phase DVSS DVSS DVDD DVDD r_phase_buf sky130_fd_sc_hs__inv_4
Xblend_left_0 l_phase_buf l_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_left_1 l_phase_buf l_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_left_2 l_phase_buf l_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_left_3 l_phase_buf l_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xblend_right_0 r_phase_buf r_con[0] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_1
Xblend_right_1 r_phase_buf r_con[1] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_2
Xblend_right_2 r_phase_buf r_con[2] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_4
Xblend_right_3 r_phase_buf r_con[3] DVSS DVSS DVDD DVDD phaseout
+ sky130_fd_sc_hs__einvp_8
Xout_buf phaseout DVSS DVSS DVDD DVDD ckout sky130_fd_sc_hs__inv_8
.ENDS

.SUBCKT osc_core glob_en delay_con_lsb[4] delay_con_lsb[3] delay_con_lsb[2]
+ delay_con_lsb[1] delay_con_lsb[0] delay_con_msb[7] delay_con_msb[6]
+ delay_con_msb[5] delay_con_msb[4] delay_con_msb[3] delay_con_msb[2]
+ delay_con_msb[1] delay_con_msb[0] con_perb_1[3] con_perb_1[2] con_perb_1[1]
+ con_perb_1[0] con_perb_2[3] con_perb_2[2] con_perb_2[1] con_perb_2[0]
+ con_perb_3[3] con_perb_3[2] con_perb_3[1] con_perb_3[0] con_perb_4[3]
+ con_perb_4[2] con_perb_4[1] con_perb_4[0] con_perb_5[3] con_perb_5[2]
+ con_perb_5[1] con_perb_5[0] ref_clk pi1_l[3] pi1_l[2] pi1_l[1] pi1_l[0]
+ pi1_r[3] pi1_r[2] pi1_r[1] pi1_r[0] pi2_l[3] pi2_l[2] pi2_l[1] pi2_l[0]
+ pi2_r[3] pi2_r[2] pi2_r[1] pi2_r[0] pi3_l[3] pi3_l[2] pi3_l[1] pi3_l[0]
+ pi3_r[3] pi3_r[2] pi3_r[1] pi3_r[0] pi4_l[3] pi4_l[2] pi4_l[1] pi4_l[0]
+ pi4_r[3] pi4_r[2] pi4_r[1] pi4_r[0] pi5_l[3] pi5_l[2] pi5_l[1] pi5_l[0]
+ pi5_r[3] pi5_r[2] pi5_r[1] pi5_r[0] osc_000 osc_036 osc_072 osc_108 osc_144
+ inj_en inj_out osc_hold p1 p2 p3 p4 p5 DVSS DVDD
XFE_PHC54_glob_en glob_en DVSS DVSS DVDD DVDD FE_PHN54_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC53_glob_en FE_PHN54_glob_en DVSS DVSS DVDD DVDD FE_PHN53_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC52_glob_en FE_PHN53_glob_en DVSS DVSS DVDD DVDD FE_PHN52_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC51_glob_en FE_PHN52_glob_en DVSS DVSS DVDD DVDD FE_PHN51_glob_en
+ sky130_fd_sc_hs__clkbuf_4
XFE_PHC50_glob_en FE_PHN51_glob_en DVSS DVSS DVDD DVDD FE_PHN50_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC49_osc_hold FE_PHN46_osc_hold DVSS DVSS DVDD DVDD FE_PHN49_osc_hold
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC48_glob_en FE_PHN50_glob_en DVSS DVSS DVDD DVDD FE_PHN48_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC47_inj_en FE_PHN22_inj_en DVSS DVSS DVDD DVDD FE_PHN47_inj_en
+ sky130_fd_sc_hs__dlygate4sd2_1
XFE_PHC46_osc_hold FE_PHN36_osc_hold DVSS DVSS DVDD DVDD FE_PHN46_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC45_inj_en FE_PHN43_inj_en DVSS DVSS DVDD DVDD FE_PHN45_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC44_glob_en FE_PHN48_glob_en DVSS DVSS DVDD DVDD FE_PHN44_glob_en
+ sky130_fd_sc_hs__buf_4
XFE_PHC43_inj_en FE_PHN45_inj_en DVSS DVSS DVDD DVDD FE_PHN41_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC42_glob_en FE_PHN44_glob_en DVSS DVSS DVDD DVDD FE_PHN42_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC41_inj_en FE_PHN41_inj_en DVSS DVSS DVDD DVDD FE_PHN39_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC40_glob_en FE_PHN42_glob_en DVSS DVSS DVDD DVDD FE_PHN40_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC39_inj_en FE_PHN39_inj_en DVSS DVSS DVDD DVDD FE_PHN37_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC38_glob_en FE_PHN40_glob_en DVSS DVSS DVDD DVDD FE_PHN38_glob_en
+ sky130_fd_sc_hs__clkbuf_2
XFE_PHC37_inj_en FE_PHN34_inj_en DVSS DVSS DVDD DVDD FE_PHN43_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC36_osc_hold FE_PHN49_osc_hold DVSS DVSS DVDD DVDD FE_PHN33_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC35_glob_en FE_PHN38_glob_en DVSS DVSS DVDD DVDD FE_PHN35_glob_en
+ sky130_fd_sc_hs__clkbuf_4
XFE_PHC34_inj_en FE_PHN37_inj_en DVSS DVSS DVDD DVDD FE_PHN31_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC33_osc_hold FE_PHN33_osc_hold DVSS DVSS DVDD DVDD FE_PHN30_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC32_glob_en FE_PHN35_glob_en DVSS DVSS DVDD DVDD FE_PHN32_glob_en
+ sky130_fd_sc_hs__bufbuf_8
XFE_PHC31_inj_en FE_PHN28_inj_en DVSS DVSS DVDD DVDD FE_PHN34_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC30_osc_hold FE_PHN30_osc_hold DVSS DVSS DVDD DVDD FE_PHN27_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC29_glob_en FE_PHN32_glob_en DVSS DVSS DVDD DVDD FE_PHN29_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC28_inj_en FE_PHN31_inj_en DVSS DVSS DVDD DVDD FE_PHN25_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC27_osc_hold FE_PHN27_osc_hold DVSS DVSS DVDD DVDD FE_PHN24_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC26_glob_en FE_PHN29_glob_en DVSS DVSS DVDD DVDD FE_PHN26_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC25_inj_en FE_PHN47_inj_en DVSS DVSS DVDD DVDD FE_PHN28_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC24_osc_hold FE_PHN24_osc_hold DVSS DVSS DVDD DVDD FE_PHN21_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC23_glob_en FE_PHN26_glob_en DVSS DVSS DVDD DVDD FE_PHN23_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC22_inj_en FE_PHN19_inj_en DVSS DVSS DVDD DVDD FE_PHN22_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC21_osc_hold FE_PHN21_osc_hold DVSS DVSS DVDD DVDD FE_PHN18_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC20_glob_en FE_PHN23_glob_en DVSS DVSS DVDD DVDD FE_PHN20_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC19_inj_en inj_en DVSS DVSS DVDD DVDD FE_PHN19_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC18_osc_hold FE_PHN18_osc_hold DVSS DVSS DVDD DVDD FE_PHN15_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC17_glob_en FE_PHN20_glob_en DVSS DVSS DVDD DVDD FE_PHN17_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC16_inj_en FE_PHN25_inj_en DVSS DVSS DVDD DVDD FE_PHN16_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC15_osc_hold FE_PHN15_osc_hold DVSS DVSS DVDD DVDD FE_PHN12_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC14_glob_en FE_PHN17_glob_en DVSS DVSS DVDD DVDD FE_PHN14_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC13_inj_en FE_PHN16_inj_en DVSS DVSS DVDD DVDD FE_PHN13_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC12_osc_hold FE_PHN12_osc_hold DVSS DVSS DVDD DVDD FE_PHN9_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC11_glob_en FE_PHN14_glob_en DVSS DVSS DVDD DVDD FE_PHN11_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC10_inj_en FE_PHN13_inj_en DVSS DVSS DVDD DVDD FE_PHN10_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC9_osc_hold FE_PHN9_osc_hold DVSS DVSS DVDD DVDD FE_PHN6_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC8_glob_en FE_PHN11_glob_en DVSS DVSS DVDD DVDD FE_PHN8_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC7_inj_en FE_PHN10_inj_en DVSS DVSS DVDD DVDD FE_PHN7_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC6_osc_hold FE_PHN6_osc_hold DVSS DVSS DVDD DVDD FE_PHN3_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC5_glob_en FE_PHN8_glob_en DVSS DVSS DVDD DVDD FE_PHN5_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC4_inj_en FE_PHN7_inj_en DVSS DVSS DVDD DVDD FE_PHN4_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC3_osc_hold FE_PHN3_osc_hold DVSS DVSS DVDD DVDD FE_PHN0_osc_hold
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC2_glob_en FE_PHN5_glob_en DVSS DVSS DVDD DVDD FE_PHN2_glob_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC1_inj_en FE_PHN4_inj_en DVSS DVSS DVDD DVDD FE_PHN1_inj_en
+ sky130_fd_sc_hs__dlygate4sd3_1
XFE_PHC0_osc_hold FE_PHN0_osc_hold DVSS DVSS DVDD DVDD osc_hold
+ sky130_fd_sc_hs__clkbuf_1
XDIODE_1 FE_PHN2_glob_en DVSS DVSS DVDD DVDD sky130_fd_sc_hs__diode_2
XLTIE DVSS DVSS DVDD DVDD LTIE_HINET 1000 sky130_fd_sc_hs__conb_1
Xdel1 osc_000 n52 osc_036 DVDD DVSS delay_cell_osc
Xpi1 osc_000 osc_036 pi1_l[3] pi1_l[2] pi1_l[1] pi1_l[0] pi1_r[3] pi1_r[2]
+ pi1_r[1] pi1_r[0] p1 DVDD DVSS phase_interpolator_4
Xdel2 osc_036 osc_hold osc_072 DVDD DVSS delay_cell_osc
Xpi2 osc_036 osc_000 pi2_l[3] pi2_l[2] pi2_l[1] pi2_l[0] pi2_r[3] pi2_r[2]
+ pi2_r[1] pi2_r[0] p2 DVDD DVSS phase_interpolator_3
Xdel3 osc_072 inj_out osc_108 DVDD DVSS delay_cell_osc
Xpi3 osc_072 osc_108 pi3_l[3] pi3_l[2] pi3_l[1] pi3_l[0] pi3_r[3] pi3_r[2]
+ pi3_r[1] pi3_r[0] p3 DVDD DVSS phase_interpolator_2
Xdel4 osc_108 n52 osc_144 DVDD DVSS delay_cell_osc
Xpi4 osc_108 osc_144 pi4_l[3] pi4_l[2] pi4_l[1] pi4_l[0] pi4_r[3] pi4_r[2]
+ pi4_r[1] pi4_r[0] p4 DVDD DVSS phase_interpolator_1
Xdel5 osc_144 n52 osc_000 DVDD DVSS delay_cell_osc
Xpi5 osc_144 osc_000 pi5_l[3] pi5_l[2] pi5_l[1] pi5_l[0] pi5_r[3] pi5_r[2]
+ pi5_r[1] pi5_r[0] p5 DVDD DVSS phase_interpolator_0
Xcapbank1_fc8_3 osc_036 delay_con_msb[3] DVSS DVSS DVDD DVDD 1001
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc8_2 osc_036 delay_con_msb[3] DVSS DVSS DVDD DVDD 1002
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc8_1 osc_036 delay_con_msb[3] DVSS DVSS DVDD DVDD 1003
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc8_0 osc_036 delay_con_msb[3] DVSS DVSS DVDD DVDD 1004
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc7_3 osc_036 delay_con_msb[2] DVSS DVSS DVDD DVDD 1005
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc7_2 osc_036 delay_con_msb[2] DVSS DVSS DVDD DVDD 1006
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc7_1 osc_036 delay_con_msb[2] DVSS DVSS DVDD DVDD 1007
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc7_0 osc_036 delay_con_msb[2] DVSS DVSS DVDD DVDD 1008
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc6_3 osc_036 delay_con_msb[1] DVSS DVSS DVDD DVDD 1009
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc6_2 osc_036 delay_con_msb[1] DVSS DVSS DVDD DVDD 1010
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc6_1 osc_036 delay_con_msb[1] DVSS DVSS DVDD DVDD 1011
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc6_0 osc_036 delay_con_msb[1] DVSS DVSS DVDD DVDD 1012
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc5_3 osc_036 delay_con_msb[0] DVSS DVSS DVDD DVDD 1013
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc5_2 osc_036 delay_con_msb[0] DVSS DVSS DVDD DVDD 1014
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc5_1 osc_036 delay_con_msb[0] DVSS DVSS DVDD DVDD 1015
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc5_0 osc_036 delay_con_msb[0] DVSS DVSS DVDD DVDD 1016
+ sky130_fd_sc_hs__nand2_4
Xcapbank1_fc44_3 osc_036 capbank1_LSB[4] DVSS DVSS DVDD DVDD 1017
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc44_2 osc_036 capbank1_LSB[4] DVSS DVSS DVDD DVDD 1018
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc44_1 osc_036 capbank1_LSB[4] DVSS DVSS DVDD DVDD 1019
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc44_0 osc_036 capbank1_LSB[4] DVSS DVSS DVDD DVDD 1020
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc4_3 osc_036 capbank1_LSB[3] DVSS DVSS DVDD DVDD 1021
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc4_2 osc_036 capbank1_LSB[3] DVSS DVSS DVDD DVDD 1022
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc4_1 osc_036 capbank1_LSB[3] DVSS DVSS DVDD DVDD 1023
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc4_0 osc_036 capbank1_LSB[3] DVSS DVSS DVDD DVDD 1024
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc3_1 osc_036 capbank1_LSB[2] DVSS DVSS DVDD DVDD 1025
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc3_0 osc_036 capbank1_LSB[2] DVSS DVSS DVDD DVDD 1026
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc2 osc_036 capbank1_LSB[1] DVSS DVSS DVDD DVDD 1027
+ sky130_fd_sc_hs__nand2_2
Xcapbank1_fc1 osc_036 capbank1_LSB[0] DVSS DVSS DVDD DVDD 1028
+ sky130_fd_sc_hs__nand2_1
Xeinj_inj_1 einj_ref_to_injector einj_inject_window FE_PHN1_inj_en DVSS DVSS
+ DVDD DVDD n41 sky130_fd_sc_hs__nand3_4
Xeinj_inj_0 einj_ref_to_injector einj_inject_window FE_PHN1_inj_en DVSS DVSS
+ DVDD DVDD n42 sky130_fd_sc_hs__nand3_4
Xeinj_inv_hold einj_inject_window DVSS DVSS DVDD DVDD FE_PHN36_osc_hold
+ sky130_fd_sc_hs__inv_16
Xeinj_dff_2 einj_ref_clk_buf LTIE_HINET einj_dff_reset DVSS DVSS DVDD DVDD n40
+ sky130_fd_sc_hs__dfrtp_4
Xeinj_dff_1 einj_ref_clk_buf LTIE_HINET einj_dff_reset DVSS DVSS DVDD DVDD n39
+ sky130_fd_sc_hs__dfrtp_4
Xeinj_dff_del_5_3 einj_rst4 DVSS DVSS DVDD DVDD n38 sky130_fd_sc_hs__inv_16
Xeinj_dff_del_5_2 einj_rst4 DVSS DVSS DVDD DVDD n37 sky130_fd_sc_hs__inv_16
Xeinj_dff_del_5_1 einj_rst4 DVSS DVSS DVDD DVDD n36 sky130_fd_sc_hs__inv_16
Xeinj_dff_del_5_0 einj_rst4 DVSS DVSS DVDD DVDD n35 sky130_fd_sc_hs__inv_16
Xeinj_dff_del_4 einj_rst3 DVSS DVSS DVDD DVDD einj_rst4 sky130_fd_sc_hs__inv_16
Xeinj_dff_del_3 einj_rst2 DVSS DVSS DVDD DVDD einj_rst3 sky130_fd_sc_hs__inv_4
Xeinj_dff_del_2 einj_rst1 DVSS DVSS DVDD DVDD einj_rst2 sky130_fd_sc_hs__inv_1
Xeinj_dff_del_1 einj_del_ref_clk DVSS DVSS DVDD DVDD einj_rst1
+ sky130_fd_sc_hs__inv_1
Xeinj_inj_del_5_3 einj_inj4 DVSS DVSS DVDD DVDD n34 sky130_fd_sc_hs__inv_16
Xeinj_inj_del_5_2 einj_inj4 DVSS DVSS DVDD DVDD n33 sky130_fd_sc_hs__inv_16
Xeinj_inj_del_5_1 einj_inj4 DVSS DVSS DVDD DVDD n32 sky130_fd_sc_hs__inv_16
Xeinj_inj_del_5_0 einj_inj4 DVSS DVSS DVDD DVDD n31 sky130_fd_sc_hs__inv_16
Xeinj_inj_del_4 einj_inj3 DVSS DVSS DVDD DVDD einj_inj4 sky130_fd_sc_hs__inv_16
Xeinj_inj_del_3 einj_inj2 DVSS DVSS DVDD DVDD einj_inj3 sky130_fd_sc_hs__inv_4
Xeinj_inj_del_2 einj_inj1 DVSS DVSS DVDD DVDD einj_inj2 sky130_fd_sc_hs__inv_1
Xeinj_inj_del_1 einj_del_ref_clk DVSS DVSS DVDD DVDD einj_inj1
+ sky130_fd_sc_hs__inv_1
Xeinj_del_64_3 einj_d3 DVSS DVSS DVDD DVDD n30 sky130_fd_sc_hs__inv_16
Xeinj_del_64_2 einj_d3 DVSS DVSS DVDD DVDD n29 sky130_fd_sc_hs__inv_16
Xeinj_del_64_1 einj_d3 DVSS DVSS DVDD DVDD n28 sky130_fd_sc_hs__inv_16
Xeinj_del_64_0 einj_d3 DVSS DVSS DVDD DVDD n27 sky130_fd_sc_hs__inv_16
Xeinj_del_16 einj_d2 DVSS DVSS DVDD DVDD einj_d3 sky130_fd_sc_hs__inv_16
Xeinj_del_4 einj_d1 DVSS DVSS DVDD DVDD einj_d2 sky130_fd_sc_hs__inv_4
Xeinj_del_1 einj_ref_clk_buf DVSS DVSS DVDD DVDD einj_d1 sky130_fd_sc_hs__inv_1
Xeinj_buf_ref ref_clk DVSS DVSS DVDD DVDD einj_ref_clk_buf
+ sky130_fd_sc_hs__inv_4
Xcapbank5_fc8_3 osc_000 delay_con_msb[3] DVSS DVSS DVDD DVDD 1029
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc8_2 osc_000 delay_con_msb[3] DVSS DVSS DVDD DVDD 1030
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc8_1 osc_000 delay_con_msb[3] DVSS DVSS DVDD DVDD 1031
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc8_0 osc_000 delay_con_msb[3] DVSS DVSS DVDD DVDD 1032
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc7_3 osc_000 delay_con_msb[2] DVSS DVSS DVDD DVDD 1033
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc7_2 osc_000 delay_con_msb[2] DVSS DVSS DVDD DVDD 1034
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc7_1 osc_000 delay_con_msb[2] DVSS DVSS DVDD DVDD 1035
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc7_0 osc_000 delay_con_msb[2] DVSS DVSS DVDD DVDD 1036
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc6_3 osc_000 delay_con_msb[1] DVSS DVSS DVDD DVDD 1037
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc6_2 osc_000 delay_con_msb[1] DVSS DVSS DVDD DVDD 1038
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc6_1 osc_000 delay_con_msb[1] DVSS DVSS DVDD DVDD 1039
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc6_0 osc_000 delay_con_msb[1] DVSS DVSS DVDD DVDD 1040
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc5_3 osc_000 delay_con_msb[0] DVSS DVSS DVDD DVDD 1041
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc5_2 osc_000 delay_con_msb[0] DVSS DVSS DVDD DVDD 1042
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc5_1 osc_000 delay_con_msb[0] DVSS DVSS DVDD DVDD 1043
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc5_0 osc_000 delay_con_msb[0] DVSS DVSS DVDD DVDD 1044
+ sky130_fd_sc_hs__nand2_4
Xcapbank5_fc44_3 osc_000 capbank5_LSB[4] DVSS DVSS DVDD DVDD 1045
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc44_2 osc_000 capbank5_LSB[4] DVSS DVSS DVDD DVDD 1046
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc44_1 osc_000 capbank5_LSB[4] DVSS DVSS DVDD DVDD 1047
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc44_0 osc_000 capbank5_LSB[4] DVSS DVSS DVDD DVDD 1048
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc4_3 osc_000 capbank5_LSB[3] DVSS DVSS DVDD DVDD 1049
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc4_2 osc_000 capbank5_LSB[3] DVSS DVSS DVDD DVDD 1050
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc4_1 osc_000 capbank5_LSB[3] DVSS DVSS DVDD DVDD 1051
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc4_0 osc_000 capbank5_LSB[3] DVSS DVSS DVDD DVDD 1052
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc3_1 osc_000 capbank5_LSB[2] DVSS DVSS DVDD DVDD 1053
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc3_0 osc_000 capbank5_LSB[2] DVSS DVSS DVDD DVDD 1054
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc2 osc_000 capbank5_LSB[1] DVSS DVSS DVDD DVDD 1055
+ sky130_fd_sc_hs__nand2_2
Xcapbank5_fc1 osc_000 capbank5_LSB[0] DVSS DVSS DVDD DVDD 1056
+ sky130_fd_sc_hs__nand2_1
Xcapbank4_fc8_3 osc_144 delay_con_msb[3] DVSS DVSS DVDD DVDD 1057
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc8_2 osc_144 delay_con_msb[3] DVSS DVSS DVDD DVDD 1058
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc8_1 osc_144 delay_con_msb[3] DVSS DVSS DVDD DVDD 1059
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc8_0 osc_144 delay_con_msb[3] DVSS DVSS DVDD DVDD 1060
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc7_3 osc_144 delay_con_msb[2] DVSS DVSS DVDD DVDD 1061
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc7_2 osc_144 delay_con_msb[2] DVSS DVSS DVDD DVDD 1062
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc7_1 osc_144 delay_con_msb[2] DVSS DVSS DVDD DVDD 1063
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc7_0 osc_144 delay_con_msb[2] DVSS DVSS DVDD DVDD 1064
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc6_3 osc_144 delay_con_msb[1] DVSS DVSS DVDD DVDD 1065
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc6_2 osc_144 delay_con_msb[1] DVSS DVSS DVDD DVDD 1066
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc6_1 osc_144 delay_con_msb[1] DVSS DVSS DVDD DVDD 1067
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc6_0 osc_144 delay_con_msb[1] DVSS DVSS DVDD DVDD 1068
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc5_3 osc_144 delay_con_msb[0] DVSS DVSS DVDD DVDD 1069
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc5_2 osc_144 delay_con_msb[0] DVSS DVSS DVDD DVDD 1070
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc5_1 osc_144 delay_con_msb[0] DVSS DVSS DVDD DVDD 1071
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc5_0 osc_144 delay_con_msb[0] DVSS DVSS DVDD DVDD 1072
+ sky130_fd_sc_hs__nand2_4
Xcapbank4_fc44_3 osc_144 capbank4_LSB[4] DVSS DVSS DVDD DVDD 1073
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc44_2 osc_144 capbank4_LSB[4] DVSS DVSS DVDD DVDD 1074
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc44_1 osc_144 capbank4_LSB[4] DVSS DVSS DVDD DVDD 1075
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc44_0 osc_144 capbank4_LSB[4] DVSS DVSS DVDD DVDD 1076
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc4_3 osc_144 capbank4_LSB[3] DVSS DVSS DVDD DVDD 1077
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc4_2 osc_144 capbank4_LSB[3] DVSS DVSS DVDD DVDD 1078
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc4_1 osc_144 capbank4_LSB[3] DVSS DVSS DVDD DVDD 1079
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc4_0 osc_144 capbank4_LSB[3] DVSS DVSS DVDD DVDD 1080
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc3_1 osc_144 capbank4_LSB[2] DVSS DVSS DVDD DVDD 1081
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc3_0 osc_144 capbank4_LSB[2] DVSS DVSS DVDD DVDD 1082
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc2 osc_144 capbank4_LSB[1] DVSS DVSS DVDD DVDD 1083
+ sky130_fd_sc_hs__nand2_2
Xcapbank4_fc1 osc_144 capbank4_LSB[0] DVSS DVSS DVDD DVDD 1084
+ sky130_fd_sc_hs__nand2_1
Xcapbank3_fc8_3 osc_108 delay_con_msb[3] DVSS DVSS DVDD DVDD 1085
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc8_2 osc_108 delay_con_msb[3] DVSS DVSS DVDD DVDD 1086
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc8_1 osc_108 delay_con_msb[3] DVSS DVSS DVDD DVDD 1087
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc8_0 osc_108 delay_con_msb[3] DVSS DVSS DVDD DVDD 1088
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc7_3 osc_108 delay_con_msb[2] DVSS DVSS DVDD DVDD 1089
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc7_2 osc_108 delay_con_msb[2] DVSS DVSS DVDD DVDD 1090
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc7_1 osc_108 delay_con_msb[2] DVSS DVSS DVDD DVDD 1091
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc7_0 osc_108 delay_con_msb[2] DVSS DVSS DVDD DVDD 1092
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc6_3 osc_108 delay_con_msb[1] DVSS DVSS DVDD DVDD 1093
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc6_2 osc_108 delay_con_msb[1] DVSS DVSS DVDD DVDD 1094
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc6_1 osc_108 delay_con_msb[1] DVSS DVSS DVDD DVDD 1095
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc6_0 osc_108 delay_con_msb[1] DVSS DVSS DVDD DVDD 1096
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc5_3 osc_108 delay_con_msb[0] DVSS DVSS DVDD DVDD 1097
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc5_2 osc_108 delay_con_msb[0] DVSS DVSS DVDD DVDD 1098
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc5_1 osc_108 delay_con_msb[0] DVSS DVSS DVDD DVDD 1099
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc5_0 osc_108 delay_con_msb[0] DVSS DVSS DVDD DVDD 1100
+ sky130_fd_sc_hs__nand2_4
Xcapbank3_fc44_3 osc_108 capbank3_LSB[4] DVSS DVSS DVDD DVDD 1101
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc44_2 osc_108 capbank3_LSB[4] DVSS DVSS DVDD DVDD 1102
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc44_1 osc_108 capbank3_LSB[4] DVSS DVSS DVDD DVDD 1103
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc44_0 osc_108 capbank3_LSB[4] DVSS DVSS DVDD DVDD 1104
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc4_3 osc_108 capbank3_LSB[3] DVSS DVSS DVDD DVDD 1105
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc4_2 osc_108 capbank3_LSB[3] DVSS DVSS DVDD DVDD 1106
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc4_1 osc_108 capbank3_LSB[3] DVSS DVSS DVDD DVDD 1107
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc4_0 osc_108 capbank3_LSB[3] DVSS DVSS DVDD DVDD 1108
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc3_1 osc_108 capbank3_LSB[2] DVSS DVSS DVDD DVDD 1109
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc3_0 osc_108 capbank3_LSB[2] DVSS DVSS DVDD DVDD 1110
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc2 osc_108 capbank3_LSB[1] DVSS DVSS DVDD DVDD 1111
+ sky130_fd_sc_hs__nand2_2
Xcapbank3_fc1 osc_108 capbank3_LSB[0] DVSS DVSS DVDD DVDD 1112
+ sky130_fd_sc_hs__nand2_1
Xcapbank2_fc8_3 osc_072 delay_con_msb[3] DVSS DVSS DVDD DVDD 1113
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc8_2 osc_072 delay_con_msb[3] DVSS DVSS DVDD DVDD 1114
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc8_1 osc_072 delay_con_msb[3] DVSS DVSS DVDD DVDD 1115
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc8_0 osc_072 delay_con_msb[3] DVSS DVSS DVDD DVDD 1116
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc7_3 osc_072 delay_con_msb[2] DVSS DVSS DVDD DVDD 1117
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc7_2 osc_072 delay_con_msb[2] DVSS DVSS DVDD DVDD 1118
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc7_1 osc_072 delay_con_msb[2] DVSS DVSS DVDD DVDD 1119
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc7_0 osc_072 delay_con_msb[2] DVSS DVSS DVDD DVDD 1120
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc6_3 osc_072 delay_con_msb[1] DVSS DVSS DVDD DVDD 1121
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc6_2 osc_072 delay_con_msb[1] DVSS DVSS DVDD DVDD 1122
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc6_1 osc_072 delay_con_msb[1] DVSS DVSS DVDD DVDD 1123
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc6_0 osc_072 delay_con_msb[1] DVSS DVSS DVDD DVDD 1124
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc5_3 osc_072 delay_con_msb[0] DVSS DVSS DVDD DVDD 1125
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc5_2 osc_072 delay_con_msb[0] DVSS DVSS DVDD DVDD 1126
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc5_1 osc_072 delay_con_msb[0] DVSS DVSS DVDD DVDD 1127
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc5_0 osc_072 delay_con_msb[0] DVSS DVSS DVDD DVDD 1128
+ sky130_fd_sc_hs__nand2_4
Xcapbank2_fc44_3 osc_072 capbank2_LSB[4] DVSS DVSS DVDD DVDD 1129
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc44_2 osc_072 capbank2_LSB[4] DVSS DVSS DVDD DVDD 1130
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc44_1 osc_072 capbank2_LSB[4] DVSS DVSS DVDD DVDD 1131
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc44_0 osc_072 capbank2_LSB[4] DVSS DVSS DVDD DVDD 1132
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc4_3 osc_072 capbank2_LSB[3] DVSS DVSS DVDD DVDD 1133
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc4_2 osc_072 capbank2_LSB[3] DVSS DVSS DVDD DVDD 1134
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc4_1 osc_072 capbank2_LSB[3] DVSS DVSS DVDD DVDD 1135
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc4_0 osc_072 capbank2_LSB[3] DVSS DVSS DVDD DVDD 1136
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc3_1 osc_072 capbank2_LSB[2] DVSS DVSS DVDD DVDD 1137
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc3_0 osc_072 capbank2_LSB[2] DVSS DVSS DVDD DVDD 1138
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc2 osc_072 capbank2_LSB[1] DVSS DVSS DVDD DVDD 1139
+ sky130_fd_sc_hs__nand2_2
Xcapbank2_fc1 osc_072 capbank2_LSB[0] DVSS DVSS DVDD DVDD 1140
+ sky130_fd_sc_hs__nand2_1
XU39 n42 n41 DVSS DVSS DVDD DVDD inj_out sky130_fd_sc_hs__and2_2
XU40 n40 n39 DVSS DVSS DVDD DVDD einj_inject_window sky130_fd_sc_hs__and2_2
XU41 n36 n35 n38 n37 DVSS DVSS DVDD DVDD einj_dff_reset sky130_fd_sc_hs__and4_2
XU42 n32 n31 n34 n33 DVSS DVSS DVDD DVDD einj_ref_to_injector
+ sky130_fd_sc_hs__and4_2
XU43 n28 n27 n30 n29 DVSS DVSS DVDD DVDD einj_del_ref_clk
+ sky130_fd_sc_hs__and4_2
XU44 delay_con_lsb[4] DVSS DVSS DVDD DVDD n43 sky130_fd_sc_hs__inv_4
XU45 n26 con_perb_1[0] n43 DVSS DVSS DVDD DVDD capbank1_LSB[4]
+ sky130_fd_sc_hs__a21oi_1
XU46 delay_con_lsb[0] DVSS DVSS DVDD DVDD n44 sky130_fd_sc_hs__inv_4
XU47 n26 con_perb_1[0] n44 DVSS DVSS DVDD DVDD capbank1_LSB[0]
+ sky130_fd_sc_hs__a21oi_1
XU48 n26 con_perb_5[0] n43 DVSS DVSS DVDD DVDD capbank5_LSB[4]
+ sky130_fd_sc_hs__a21oi_1
XU49 n26 con_perb_5[0] n44 DVSS DVSS DVDD DVDD capbank5_LSB[0]
+ sky130_fd_sc_hs__a21oi_1
XU50 n26 con_perb_4[0] n43 DVSS DVSS DVDD DVDD capbank4_LSB[4]
+ sky130_fd_sc_hs__a21oi_1
XU51 n26 con_perb_4[0] n44 DVSS DVSS DVDD DVDD capbank4_LSB[0]
+ sky130_fd_sc_hs__a21oi_1
XU52 n26 con_perb_3[0] n43 DVSS DVSS DVDD DVDD capbank3_LSB[4]
+ sky130_fd_sc_hs__a21oi_1
XU53 n26 con_perb_3[0] n44 DVSS DVSS DVDD DVDD capbank3_LSB[0]
+ sky130_fd_sc_hs__a21oi_1
XU54 n26 con_perb_2[0] n43 DVSS DVSS DVDD DVDD capbank2_LSB[4]
+ sky130_fd_sc_hs__a21oi_1
XU55 n26 con_perb_2[0] n44 DVSS DVSS DVDD DVDD capbank2_LSB[0]
+ sky130_fd_sc_hs__a21oi_1
XU56 delay_con_lsb[3] DVSS DVSS DVDD DVDD n45 sky130_fd_sc_hs__inv_4
XU57 n26 con_perb_2[3] n45 DVSS DVSS DVDD DVDD capbank2_LSB[3]
+ sky130_fd_sc_hs__a21oi_1
XU58 delay_con_lsb[2] DVSS DVSS DVDD DVDD n46 sky130_fd_sc_hs__inv_4
XU59 n26 con_perb_2[2] n46 DVSS DVSS DVDD DVDD capbank2_LSB[2]
+ sky130_fd_sc_hs__a21oi_1
XU60 delay_con_lsb[1] DVSS DVSS DVDD DVDD n47 sky130_fd_sc_hs__inv_4
XU61 n26 con_perb_2[1] n47 DVSS DVSS DVDD DVDD capbank2_LSB[1]
+ sky130_fd_sc_hs__a21oi_1
XU62 n26 con_perb_3[3] n45 DVSS DVSS DVDD DVDD capbank3_LSB[3]
+ sky130_fd_sc_hs__a21oi_1
XU63 n26 con_perb_3[2] n46 DVSS DVSS DVDD DVDD capbank3_LSB[2]
+ sky130_fd_sc_hs__a21oi_1
XU64 n26 con_perb_3[1] n47 DVSS DVSS DVDD DVDD capbank3_LSB[1]
+ sky130_fd_sc_hs__a21oi_1
XU65 n26 con_perb_4[3] n45 DVSS DVSS DVDD DVDD capbank4_LSB[3]
+ sky130_fd_sc_hs__a21oi_1
XU66 n26 con_perb_4[2] n46 DVSS DVSS DVDD DVDD capbank4_LSB[2]
+ sky130_fd_sc_hs__a21oi_1
XU67 n26 con_perb_4[1] n47 DVSS DVSS DVDD DVDD capbank4_LSB[1]
+ sky130_fd_sc_hs__a21oi_1
XU68 n26 con_perb_5[3] n45 DVSS DVSS DVDD DVDD capbank5_LSB[3]
+ sky130_fd_sc_hs__a21oi_1
XU69 n26 con_perb_5[2] n46 DVSS DVSS DVDD DVDD capbank5_LSB[2]
+ sky130_fd_sc_hs__a21oi_1
XU70 n26 con_perb_5[1] n47 DVSS DVSS DVDD DVDD capbank5_LSB[1]
+ sky130_fd_sc_hs__a21oi_1
XU71 n26 con_perb_1[3] n45 DVSS DVSS DVDD DVDD capbank1_LSB[3]
+ sky130_fd_sc_hs__a21oi_1
XU72 n26 con_perb_1[2] n46 DVSS DVSS DVDD DVDD capbank1_LSB[2]
+ sky130_fd_sc_hs__a21oi_1
XU73 n26 con_perb_1[1] n47 DVSS DVSS DVDD DVDD capbank1_LSB[1]
+ sky130_fd_sc_hs__a21oi_1
XU1 ref_clk DVSS DVSS DVDD DVDD n26 sky130_fd_sc_hs__inv_4
XU78 FE_PHN2_glob_en DVSS DVSS DVDD DVDD n52 sky130_fd_sc_hs__clkbuf_4
.ENDS
